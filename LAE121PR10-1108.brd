# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW2_DP2_P1_C: length 5.1
  TOP w0.104: v2(237.36,74.01) 237.17,74.21 236.64,74.21 CV153.2
  BOTTOM w0.104: v2(237.36,74.01) 237.55,74.2 239.47,74.2 239.62,74.05 240.08,74.05 240.23,73.9 JNGFF1.28
SW2_DP2_P2: length 159.3
  IN3 w0.135: v2(227.5,75.32) 227.55,75.37 227.66,75.37 227.79,75.24 227.79,75 227.68,74.89 223.32,74.89 220.86,72.44 220.86,70.72 219.21,69.06 206.32,69.06 205.53,69.86 195.74,69.86 arc(186.03,71.79) 177.8,77.29 177.01,78.08 arc(170.47,87.87) 168.17,99.43 168.17,106.52 163.08,111.62 163.08,113.72 155.87,120.93 153.77,120.93 149.46,125.23 135.74,125.23 134.44,126.53 131.79,126.53 129.08,129.23 128.61,129.23 125.96,131.89 116.38,131.89 115.27,133 115.27,133.79 115.36,133.88 v2(115.44,133.88)
  BOTTOM w0.104: UV7.45 115.11,133.13 115.26,133.28 115.26,133.83 115.32,133.88 v2(115.44,133.88) ; v2(227.5,75.32) 227.55,75.37 227.66,75.37 227.81,75.22 227.81,74.53 228.07,74.27 229.16,74.27 CV147.1
SW2_DP2_P2_C: length 3.2
  BOTTOM w0.104: JNGFF1.27 232.59,74.15 232.46,74.28 230.77,74.28 CV147.2
SW2_DP2_P3: length 162.3
  IN3 w0.135: v2(228.22,76.05) 228.22,76.14 228.3,76.22 228.58,76.22 228.74,76.06 228.74,74.97 227.83,74.05 223.5,74.05 221.55,72.11 221.55,70.42 219.51,68.38 205.94,68.38 205.14,69.18 195.72,69.18 arc(185.77,71.16) 177.33,76.79 176.53,77.6 arc(169.84,87.61) 167.49,99.43 167.49,106.22 162.23,111.48 162.23,113.55 155.53,120.25 153.46,120.25 149.17,124.53 135.34,124.53 134.11,125.77 131.38,125.77 129.45,127.7 124.31,127.7 121.73,130.27 119.99,130.27 119.68,130.59 116.03,130.59 114.02,132.6 114.02,133.52 114.17,133.67 v2(114.22,133.67)
  BOTTOM w0.104: v2(114.22,133.67) 114.12,133.67 114.02,133.56 114.02,133.25 113.81,133.05 113.81,132.78 113.91,132.68 UV7.42 ; v2(228.22,76.05) 228.17,75.99 228.17,75.84 228.27,75.73 228.5,75.73 228.62,75.86 228.62,76.26 228.71,76.35 229.16,76.35 229.5,76.01 CV146.1
SW2_DP2_P3_C: length 3.4
  BOTTOM w0.104: CV146.2 230.75,76.23 230.95,76.23 231.01,76.29 231.92,76.29 232.41,75.8 232.59,75.8 232.74,75.65 JNGFF1.21
SW2_PS8338_CFG0: length 1.6
  BOTTOM w0.112: RV85.1 119.2,128.34 UV7.59
SW2_PS8338_P0: length 1.8
  BOTTOM w0.112: RV95.1 118.72,127.94 UV7.60
SW2_PS8338_P1: length 4.6
  BOTTOM w0.107: RV94.1 RV93.1 119.01,126.82 117.18,126.82 117.11,126.89 UV7.1
  BOTTOM w0.112: RV94.1 v1(118.38,125.55)
SW2_PS8338_PC10: length 2.7
  BOTTOM w0.112: UV7.56 118.68,129.54 RV90.1 RV91.1
SW2_PS8338_PC11: length 7.7
  BOTTOM w0.112: UV7.55 118.27,129.94 119.48,131.15 120.8,131.15 120.98,131.33 122.4,131.33 RV83.1 RV84.1 v1(124.75,131.82)
SW2_PS8338_PC20: length 4.8
  BOTTOM w0.107: RV81.1 RV82.1
  BOTTOM w0.112: UV7.54 118.29,130.34 119.32,131.37 120.66,131.37 RV82.1
SW2_PS8338_PC21: length 2.9
  BOTTOM w0.112: RV80.1 RV79.1 119.34,131.76 118.32,130.74 UV7.53
SW2_PS8338_PEQ: length 3.8
  TOP w0.112: RV88.1 RV87.1 114.57,126.12 114.51,126.07 v2(114.51,126.07) v1(113.75,126.07)
  BOTTOM w0.107: v2(114.51,126.07) 114.51,126.07 114.31,126.28 UV7.8
SW2_PS8338_SW: length 4.4
  BOTTOM w0.112: UV7.18 110.31,126.8 109.69,126.19 108.85,126.19 RV89.1 107.42,124.75 v1(107.42,124.5)
SW_+1VALWP: length 2
  TOP w0.112: 159.28,83.7 v1(161.29,83.7)
  vias: v2(157.25,83.01) v2(157.85,83.01)
SW_USB20_N1: length 3.6
  TOP w0.104: UI3.11 277.01,73.95 276.81,73.74 276.81,73.4 v2(277.05,73.15)
  BOTTOM w0.104: LI7.1 277.34,74.26 277.06,74.54 276.82,74.54 276.67,74.38 276.67,73.53 277.04,73.15 v2(277.05,73.15)
SW_USB20_P1: length 3.7
  TOP w0.104: v2(276.47,73.15) 276.6,73.29 276.6,73.85 276.51,73.95 UI3.10
  BOTTOM w0.104: LI7.4 277.2,74.86 277.07,74.74 276.74,74.74 276.44,74.43 v4(276.44,73.98) 276.44,73.18 v2(276.47,73.15)
SYS_LED_MASK#: length 105.3
  TOP w0.112: UZ10.1 268.89,84.83 v2(269.7,85.63) ; UE1.A12 246.53,92.66 245.87,93.32 245.87,94.3 v2(246.07,94.5) 245.9,94.68 245.9,95.82 RE21.1
  IN1 w0.119: v2(246.64,112.17) 246.64,110.65 246.94,110.36 246.94,106.36 245.16,104.59 245.16,96.73 246.07,95.82 v2(246.07,94.5)
  IN2 w0.124: v2(254.62,128.43) 254.62,126.34 252.53,124.24 252.53,115.82 254.08,114.27 254.08,112.46 v2(253.8,112.18)
  IN3 w0.135: v2(253.8,112.18) 253.8,112.56 254.25,113.02 255.01,113.02 256.92,111.11 256.92,106.39 258.82,104.48 265.71,104.48 266.93,103.26 266.93,103.25 268.81,101.37 268.81,98.92 271.91,95.82 271.91,86.59 270.95,85.63 v2(269.7,85.63)
  BOTTOM w0.112: v2(254.62,128.43) 254.62,129.87 254.86,130.1 v1(255.31,130.1) 257.08,130.1 257.25,130.27 257.25,130.74 257.14,130.86 QL1.2 257.14,131.84 257.33,132.03 257.33,132.47 257.14,132.66 QL1.5 257.14,133.92 257.45,134.24 258.39,134.24 258.7,133.93 258.7,132.62 259.15,132.17 259.78,132.17 259.99,131.95 QL2.2 ; v2(253.8,112.18) 253.51,112.48 247.1,112.48 246.8,112.17 v2(246.64,112.17)
SYS_PWROK: length 236.4
  TOP w0.112: v2(232.1,83.09) v3(234.02,83.09) 234.54,83.09 235.74,84.29 RE56.1 236.6,84.77 v2(237.23,84.77) ; UE1.G4 v2(251.08,85.86) ; v2(162.11,123.49) 162.11,120.33 164.82,117.63 164.82,115.91 163.42,114.51 163.42,110.3 168.48,105.24 168.48,99.35 arc(169.44,91.87) 172.26,84.87 arc(175.62,80.03) 179.83,75.91 arc(187.25,71.66) 195.66,70.19 209.29,70.19 210.41,71.31 210.41,72.13 214.5,74.59 217.22,74.59 218.13,73.67 220.18,73.67 arc(223.06,74.86) 224.26,77.75 224.26,79.28 v2(225.26,80.29)
  IN2 w0.124: v2(251.08,85.86) 250.68,86.26 247.53,86.26 246.67,87.12 243,87.12 242.46,87.66 241.86,87.66 240.66,88.87 239.19,88.87 237.95,87.62 237.95,85.49 v2(237.23,84.77) ; v2(225.26,80.29) 225.55,80 229.01,80 v2(232.1,83.09) ; v2(89.2,125.59) 90.08,126.48 93.14,126.48 93.27,126.6 95.24,126.6 95.59,126.96 98.83,126.96 99.16,126.63 103.86,126.63 104.29,127.06 105.76,127.06 106.45,127.75 109.47,127.75 109.79,127.43 118.89,127.43 119.28,127.82 121.93,127.82 122.69,127.06 125.45,127.06 125.82,127.42 128.23,127.42 128.86,126.79 133.64,126.79 136.08,124.36 136.08,123.08 136.92,122.24 136.92,120.92 v2(136.47,120.47)
  IN3 w0.135: v2(136.47,120.47) 136.47,119.88 136.82,119.53 148.32,119.53 v2(148.51,119.72)
  BOTTOM w0.076: 131.85,113.22 131.62,112.99 130.02,112.99 129.82,112.79 129.82,112.59 UC1.B6
  BOTTOM w0.112: v2(136.47,120.47) 136.47,119.66 132.66,115.86 132.66,114.03 131.85,113.22 ; v2(148.51,119.72) 148.51,119.73 152.65,123.87 161.74,123.87 v2(162.11,123.49) ; RC129.1 89.37,125.76 v2(89.2,125.59)
SYS_RESET#: length 221.9
  TOP w0.112: v1(258.19,106.42) 258.56,106.8 JAPS1.13 v2(258.56,109.33)
  IN1 w0.119: v2(215.59,75.07) 216.69,73.97 221.74,73.97 223.52,75.75 223.52,81.24 226.05,83.77 v2(226.05,85.84)
  BOTTOM w0.076: 133.12,111.64 132.76,112 132.21,112 132,111.8 131.72,111.8 131.52,112 130.58,112 130.15,112.43 UC1.B5
  BOTTOM w0.112: 133.12,111.64 134.64,111.64 135.51,112.51 135.51,114.98 138.43,117.91 144.07,117.91 146.66,115.31 RC291.1 CC302.1 148.27,114.45 RC224.2 149.71,113.01 152.66,113.01 153.27,113.62 153.27,117.04 152.55,117.76 152.55,120.79 154.01,122.25 162.61,122.25 164.03,120.83 164.03,111.05 166.01,109.07 166.01,107.52 166.79,106.74 166.79,103.5 168.8,101.49 168.8,92.96 170.94,90.82 170.94,86.19 185.95,71.18 209.27,71.18 209.52,71.44 209.52,72.35 211.28,72.99 213.38,73.95 215.26,75.07 v2(215.59,75.07) ; v2(258.56,109.33) 258.13,108.9 254.52,108.9 253.88,108.27 251.31,108.27 250.7,108.88 244.02,108.88 239.54,113.35 237.07,113.35 236.92,113.2 236.92,112.06 236.38,111.52 235.07,111.52 231.63,108.08 230.12,108.08 228.88,106.85 228.88,96.77 228.62,96.5 228.62,88.41 v2(226.05,85.84)
SYS_RESET#_R: length 2.3
  BOTTOM w0.112: RC290.2 RC224.1 149.96,114.56 149.85,114.68 UC12.4
TBT_CIO_PLUG_EVENT#: length 184.3
  TOP w0.076: UT1.W2 32.8,96.79 32.8,96.37 32.92,96.25 32.92,95.87 33.17,95.62 33.17,95.41
  TOP w0.112: 33.17,95.41 33.17,94.75 v2(33.81,94.12) ; v2(40.16,112.28) 40,112.28 39.32,111.59 39.32,110.02 38.89,109.59 38.35,109.59 37.06,108.29 36.3,108.29 v2(36.3,108.29)
  IN2 w0.124: v2(126.14,102.63) 126.14,102.79 126.51,103.17 132.8,103.17 132.99,103.36 136.38,103.36 136.88,103.86 136.88,104.89 136.67,105.09 135.71,105.09 135.15,105.65 135.15,110.02 134.68,110.49 134.68,111.21 135.01,111.54 135.01,118.22 133.73,119.5 133.73,120.81 134.16,121.25 134.16,123.35 v2(134.34,123.53) 134.34,124.98 133.21,126.11 122.68,126.11 121.66,127.14 120.47,127.14 120.06,126.73 111.71,126.73 111.25,126.27 104.62,126.27 104.19,125.84 98.09,125.84 97.1,124.85 93.62,124.85 93.22,125.26 91.72,125.26 91.05,124.59 85.91,124.59 85.57,124.93 83.08,124.93 81.79,123.63 74.29,123.63 72.75,125.17 71.96,125.17 71.89,125.11 71.3,125.11 71.23,125.17 70.84,125.57 68.14,125.57 67.66,125.09 62.71,125.09 61.94,124.32 61.94,124.28 59.21,121.55 56.05,121.55 53.73,123.87 46.99,123.87 46.42,123.3 41.07,123.3 40.46,122.69 40.46,120.74 42.21,118.98 44.12,118.98 44.88,118.22 44.88,115.35 41.81,112.28 v2(40.16,112.28) ; v2(36.3,108.29) 36.42,108.16 36.42,101.81 36.93,101.31 36.93,95.41 35.93,94.42 34.34,94.42 34.04,94.12 v2(33.81,94.12)
  BOTTOM w0.076: v2(126.14,102.63) UC1.AB12
  BOTTOM w0.102: RT371.1 35.66,92.8 v1(35.2,92.34)
  BOTTOM w0.112: RT371.1 36.22,93.16 35.26,94.12 v2(33.81,94.12) ; v2(134.34,123.53) 134.06,123.25 RT391.1
TBT_DP_RBIAS: length 9.2
  TOP w0.102: UT1.N6 v2(30.34,99.34)
  IN3 w0.135: v2(30.34,99.34) 29.89,99.78 29.89,100.21 30.11,100.42 31.17,100.42 31.79,99.8 34.24,99.8 35.36,98.69 v2(35.36,98.66)
  BOTTOM w0.112: v1(35.48,97.93) 35.36,98.05 v2(35.36,98.66) 35.36,99.15 RT35.1
TBT_FORCE_PWR: length 179.1
  TOP w0.102: v2(27.09,98.04) UT1.H4
  IN1 w0.119: v2(122.71,134.5) 122.71,128.74 124.18,127.26 129.41,127.26 130.53,126.15 131.42,126.15 132.03,125.54 132.03,125.27 v2(132.52,124.78)
  IN2 w0.124: v2(132.52,124.78) 132.52,124.31 133.02,123.81 133.02,121.85 132.59,121.42 132.59,119.05 133.15,118.49 133.15,116.14 132.71,115.71 v2(130.42,115.71) ; v2(122.71,134.5) 121.89,135.32 90.05,135.32 88.23,133.49 83.66,133.49 79.14,128.97 75.99,128.97 75.67,129.3 66.98,129.3 66.67,128.99 62.19,128.99 61.27,128.07 46.9,128.07 45.79,126.96 40.56,126.96 40.26,126.66 36.83,126.66 34.54,124.37 31.16,124.37 30,123.2 30,111.87 30.38,111.49 30.38,109.38 30.89,108.88 32.54,108.88 35.66,105.75 35.66,100.11 34.87,99.32 34.87,96.84 35.13,96.58 35.13,95.77 34.9,95.54 33.98,95.54 32.69,96.84 27.66,96.84 27.09,97.41 v2(27.09,98.04)
  BOTTOM w0.112: UC1.B7 128.6,112.96 128.6,113.47 130.25,115.12 130.25,115.53 v2(130.42,115.71) ; v2(27.09,98.04) v1(26.38,97.33) 25.77,96.72 25.77,96.21 25.63,96.07 25.63,93.32 RT27.1
TBT_I2C_SCL: length 17.4
  TOP w0.076: UT5.D2 32.77,83.22 32.77,83.81 33.02,84.06 33.02,84.36 33.16,84.51 ; UT1.U2 31.88,96.79 31.88,96 31.68,95.8 31.68,95.44 31.7,95.43 31.7,95.41
  TOP w0.112: 33.16,84.51 v2(33.22,84.57) ; 31.7,95.41 31.7,95.34 32.16,94.88 32.16,93.4 31.29,92.53 31.29,91.41 RT19.1 31.46,90.61 v2(31.46,90.18)
  IN1 w0.119: v2(33.22,84.57) 33.39,84.74 33.7,84.74 34,85.04 34,85.83 32.47,87.36 32.47,89.11 32.03,89.55 31.52,89.55 31.3,89.77 31.3,90.02 v2(31.46,90.18)
TBT_I2C_SDA: length 17.2
  TOP w0.076: 31.46,95.41 31.46,95.43 31.48,95.44 31.48,95.89 31.68,96.09 31.68,96.17 31.61,96.23 31.53,96.23 31.43,96.33 31.43,96.67 31.49,96.73 31.6,96.73 31.66,96.67 UT1.U1 ; UT5.D1 32.52,83.94 32.79,84.21 32.79,84.51
  TOP w0.112: v2(33.22,85.15) 32.79,84.72 32.79,84.51 ; v2(30.85,90.18) 30.85,90.65 RT18.1 31.05,91.41 31.05,92.63 31.92,93.49 31.92,94.78 31.46,95.24 31.46,95.41
  IN1 w0.119: v2(30.85,90.18) 31.05,89.98 31.05,89.67 31.42,89.3 31.93,89.3 32.22,89.01 32.22,87.26 33.75,85.73 33.75,85.14 33.59,84.98 33.39,84.98 v2(33.22,85.15)
TBT_JTAG_TCK: length 5.9
  TOP w0.102: v2(30.99,98.04) UT1.T4
  BOTTOM w0.112: RT6.1 32.97,94.82 v1(32.92,94.77) 32.18,94.77 31.39,95.55 31.39,97.63 v2(30.99,98.04)
TBT_JTAG_TDI: length 2.4
  TOP w0.076: UT1.Y4 v2(32.94,98.03)
  BOTTOM w0.112: v2(32.94,98.03) 33.28,98.37 RT8.1 33.67,99.2 v1(33.51,99.35)
TBT_JTAG_TDO: length 2.1
  TOP w0.102: v2(32.29,98.04) UT1.W4
  BOTTOM w0.112: RT5.1 32.76,97.48 v1(32.67,97.57) 32.29,97.96 v2(32.29,98.04)
TBT_JTAG_TMS: length 3.4
  TOP w0.102: UT1.V4 v2(31.64,98.04)
  BOTTOM w0.112: v2(31.64,98.04) 31.64,96.63 v1(31.9,96.37) 32.74,96.37 RT7.1
TBT_PCIE_RBIAS: length 5.5
  TOP w0.112: UT1.N16 v2(30.34,103.89)
  BOTTOM w0.112: v2(30.34,103.89) 30.35,103.9 30.35,104.4 30.71,104.76 31.85,104.76 32.56,105.47 RT34.1 31.99,106.63 v1(31.48,106.63)
TBT_PWR_EN: length 11.4
  BOTTOM w0.076: UC1.D7 129.35,111.82 129.35,112.16 129.26,112.28 129.26,112.41 129.31,112.47 129.31,113.22 131.72,115.63
  BOTTOM w0.112: T269.1 135.28,119.19 131.72,115.63
TBT_RBIAS: length 2.3
  TOP w0.102: UT1.H6 27.41,99.01 v2(27.08,98.68)
  BOTTOM w0.112: RT39.2 27.66,99.21 27.61,99.21 v2(27.08,98.68)
TBT_RESET_N_EC: length 399.7
  TOP w0.102: UT1.F4 26.76,97.71 v2(26.44,98.04)
  TOP w0.112: v2(260.08,90.98) 259.82,90.71 RE506.1 ; v2(235.36,60.02) 234.22,61.15 229.96,61.15 229.61,60.81 229.61,59.74 229.23,59.36 228.28,59.36 227.11,60.53 220.26,60.53 219.54,59.81 219.54,55.65 217.85,53.96 v2(217.85,53.24) ; RT110.2 v2(30.89,74.81)
  IN1 w0.119: v2(161.7,56.25) 161.7,56.35 161.36,56.68 160.68,56.68 160.44,56.44 148.02,56.44 146.28,54.7 142.47,54.7 141.12,53.35 129.95,53.35 126.87,50.28 73.86,50.28 72.64,51.5 v2(71.93,51.5) ; v2(15.39,92.4) 15.39,91.51 15.41,91.49 15.41,90.98 15.41,90.97 15.41,82.95 18.08,80.27 19.23,80.27 19.46,80.05 22.74,80.05 22.99,80.29 22.99,80.63 23.39,81.04 25.04,81.04 26.06,80.02 26.06,76.77 27.2,75.63 30.07,75.63 v2(30.89,74.81)
  IN2 w0.124: v2(161.7,56.25) 162.82,55.12 177.8,55.12 179.89,53.02 184.53,53.02 185.87,51.69 196.89,51.69 197.95,52.75 201.65,52.75 202.67,51.73 206.25,51.73 207.01,52.49 209.24,52.49 209.96,53.21 213.96,53.21 214.43,52.74 217.36,52.74 v2(217.85,53.24)
  IN3 w0.135: v2(235.36,60.02) 235.91,59.46 238.63,59.46 242.66,63.49 242.66,63.66 244.4,65.4 244.4,67.24 244.83,67.68 244.83,68.78 246.04,69.99 246.04,73.71 245.31,74.44 245.31,77.66 246.55,78.9 246.55,80.32 245.65,81.22 245.65,81.86 246.91,83.12 246.91,84.54 246.61,84.85 246.61,88.45 247.56,89.41 256.04,89.41 257.62,90.98 v2(260.08,90.98) ; v2(71.93,51.5) 71.25,51.5 68.5,54.24 65.51,54.24 61.19,49.92 39.04,49.92 37.01,51.95 25.53,51.95 24.59,51.01 24.59,46.48 22.44,44.33 14.63,44.33 14.27,44.69 14.27,51.62 17.81,55.16 18.97,55.16 19.76,55.94 19.76,68.1 14.12,73.73 14.12,91.64 14.88,92.4 v2(15.39,92.4)
  BOTTOM w0.112: v2(15.39,92.4) 15.9,91.9 21.66,91.9 v1(23.3,93.53) 24.98,95.21 RT11.1 25.12,95.22 25.12,96.09 25.56,96.52 25.56,97.16 v2(26.44,98.04)
TBT_RESET_N_EC_R: length 9
  TOP w0.107: UE1.L8 v2(255.08,89.86)
  TOP w0.112: v1(258.39,91.27) 258.75,91.63 RE506.2 v2(260.08,91.63) 260.3,91.63 RE95.1
  IN3 w0.135: v2(255.08,89.86) 256.86,91.63 v2(260.08,91.63)
TBT_ROM_CLK: length 13.4
  TOP w0.076: UT1.AB4 33.96,97.93 34.19,97.69 34.72,97.69 35.13,97.28 35.13,97.04 35.35,96.82
  TOP w0.112: v2(35.61,96.68) 35.48,96.68 35.35,96.82
  BOTTOM w0.112: v2(35.61,96.68) 36.19,96.1 v1(36.19,93.94) 36.19,93.88 37.35,92.72 37.35,91.02 35.77,89.44 35.77,88.28 35.58,88.09 34.82,88.09 UT2.6
TBT_ROM_CS#: length 17.4
  TOP w0.076: UT1.AC3 34.59,97.47 34.92,97.14 34.92,96.76 35.18,96.51 35.18,96.3 35.23,96.25
  TOP w0.112: 35.23,96.25 35.38,96.1 v2(35.61,96.1) ; RT2.1 38.14,89.42 v2(38.57,89.42)
  IN1 w0.119: v2(38.57,89.42) 37.74,90.24 37.74,92.86 38.29,93.41 38.3,93.41 38.3,95.1 37.86,95.54 36.6,95.54 36.04,96.1 v2(35.61,96.1)
  BOTTOM w0.102: UT2.1 v3(41.88,91.96)
  BOTTOM w0.112: UT2.1 39.58,90.43 v2(38.57,89.42)
TBT_ROM_DI: length 19.4
  TOP w0.076: 35.03,96.04 34.95,96.12 34.95,96.45 34.74,96.66 34.74,97.08 34.58,97.24 34.19,97.24 UT1.AB3
  TOP w0.112: 35.03,96.04 35.03,96.02 35.53,95.51 v2(35.61,95.51)
  IN1 w0.119: v2(35.61,95.51) 35.81,95.51 36.04,95.29 37.65,95.29 38.02,94.92 38.02,93.48 37.13,92.59 37.13,89.33 38.42,88.05 38.42,86.67 38.11,86.36 36.72,86.36 v2(36.41,86.67)
  BOTTOM w0.112: UT2.5 36.37,86.62 v2(36.41,86.67) ; v2(35.61,95.51) 35.61,95.24 v1(35.41,95.03)
TBT_ROM_DO: length 18.7
  TOP w0.076: UT1.AC4 34.9,97.93 35.35,97.48
  TOP w0.112: v2(35.61,97.29) 35.53,97.29 35.35,97.48 ; RT3.1 38.39,88.78 v2(38.57,88.78)
  IN1 w0.119: v2(35.61,97.29) 37.11,95.79 37.96,95.79 38.56,95.2 38.56,93.32 38.02,92.79 38.02,90.6 39,89.62 39,89.22 v2(38.57,88.78)
  BOTTOM w0.102: UT2.2 43.01,89.16 v3(43.46,88.72)
  BOTTOM w0.112: UT2.2 41.17,89.16 41.02,89.32 39.74,89.32 39.2,88.78 v2(38.57,88.78)
TBT_ROM_HOLD#: length 3.3
  BOTTOM w0.112: UT2.7 33.15,89.16 32.76,88.78 v1(32.66,88.78) 32.45,88.78 32.21,89.03 RT1.1
TBT_ROM_WP#: length 20.5
  TOP w0.076: UT1.V1 v2(32.12,95.68)
  TOP w0.112: v2(37.95,86.8) RT4.1
  IN1 w0.119: v2(32.12,95.68) 33.32,95.68 34.5,94.5 35.41,94.5 36.24,93.67 36.24,89.77 37.95,88.07 v2(37.95,86.8)
  BOTTOM w0.102: v3(43.39,86.88) 42.38,87.89 UT2.3
  BOTTOM w0.112: v2(37.95,86.8) 37.95,86.98 38.42,87.45 40.73,87.45 41.17,87.89 UT2.3
TBT_RSENSE: length 1.9
  TOP w0.102: UT1.J6 28.06,99.01 27.75,99.32 v2(27.08,99.32)
  BOTTOM w0.112: v2(27.08,99.32) 27.08,99.48 27.51,99.91 RT39.1
TBT_SRC_CFG1: length 6.6
  TOP w0.076: 34.07,95.41 33.88,95.59 33.88,95.9 33.5,96.28 UT1.AA1
  TOP w0.112: 34.07,95.41 34.29,95.18 34.53,95.18 36.11,93.61 36.6,93.61 37.11,93.1 RT338.1 RT30.1
TBT_TMU_CLK_OUT: length 4.4
  TOP w0.076: 32.56,95.41 32.56,96.06 32.35,96.27 32.35,96.78 UT1.V2
  TOP w0.112: 32.56,95.41 32.56,95.16 32.66,95.06 RT28.1
TBTA_AUXN: length 24.1
  TOP w0.102: UT1.W15 v2(32.28,103.24)
  TOP w0.112: CT81.1 28.44,88.85 28.44,89.18 v2(28.28,89.34)
  IN3 w0.135: v2(28.28,89.34) 28.43,89.49 28.43,90.03 28.8,90.4 29.75,90.4 30.67,91.32 31.58,91.32 32.76,92.51 32.76,94.35 33.46,95.04 35.81,95.04 36.52,95.76 36.52,100.87 35.01,102.39 32.77,102.39 32.47,102.69 32.47,103.05 32.28,103.24 v2(32.28,103.24)
TBTA_AUXN_C: length 6
  TOP w0.076: 29.18,84.32 29.19,84.31 29.22,84.31 29.77,83.75 29.77,83.23 UT5.J2
  TOP w0.112: CT81.2 28.28,87.44 RT95.1 28.41,86.96 28.41,86.65 28.73,86.33 28.73,84.77 29.18,84.32
TBTA_AUXP: length 24.2
  TOP w0.102: UT1.Y15 33,102.91 32.94,102.97 v2(32.94,103.24)
  TOP w0.112: v2(28.86,89.34) 28.7,89.18 28.7,88.85 CT80.1
  IN3 w0.135: v2(32.94,103.24) 32.75,103.06 32.75,102.81 32.89,102.68 35.12,102.68 36.81,100.99 36.81,95.64 35.92,94.75 33.57,94.75 33.05,94.23 33.05,92.39 31.7,91.04 30.79,91.04 29.87,90.12 28.92,90.12 28.71,89.91 28.71,89.49 v2(28.86,89.34)
TBTA_AUXP_C: length 5.4
  TOP w0.076: 29.36,84.51 29.38,84.49 29.38,84.47 30,83.85 30,83.5 UT5.J1
  TOP w0.112: CT80.2 28.85,87.37 RT96.1 28.67,86.97 28.67,86.76 28.99,86.44 28.99,84.88 29.36,84.51
TBTA_BOT_N: length 41.3
  TOP w0.076: 27.96,80.37 27.98,80.37 28.16,80.54 28.61,80.54 28.68,80.47 UT5.L7
  TOP w0.112: 27.96,80.37 v2(27.76,80.16)
  IN1 w0.119: v2(15.84,98.66) 15.75,98.66 15.67,98.59 15.67,98.49 15.58,98.4 15.58,98.24 15.87,97.95 15.87,93.13 16.66,92.34 16.66,88.43 17.58,87.51 22.34,87.51 22.81,87.51 23.24,87.08 23.24,82.26 23.58,81.92 25.41,81.92 26.94,80.39 26.94,80.1 27.6,79.44 27.88,79.44 28.15,79.71 28.15,79.84 27.83,80.16 v2(27.76,80.16)
  IN2 w0.124: v2(15.84,98.66) 15.67,98.83 15.67,98.84 15.66,98.85 15.66,99.34 15.82,99.49 15.82,103.55 16.92,104.65 16.92,106.11 v2(17.04,106.23)
  BOTTOM w0.112: RT122.2 15.89,106.84 16.43,106.84 v2(17.04,106.23)
TBTA_BOT_N_R: length 8.7
  BOTTOM w0.112: JUSBC1.B7 6.8,107.35 v4(8.1,107.35) 10.41,107.35 10.65,107.11 12.2,107.11 12.49,106.83 13.65,106.83 DT20.1 14.09,106.82 14.37,106.82 RT122.1
TBTA_BOT_P: length 41.3
  TOP w0.076: v2(28.4,80.18) 28.4,80.08 28.48,80.01 28.66,80.01 28.88,80.22 29.12,80.22 29.37,80.47 UT5.K7
  IN1 w0.119: v2(28.4,80.18) 28.4,79.61 28.19,79.4 27.98,79.19 27.49,79.19 26.69,79.99 26.69,80.28 25.3,81.66 23.47,81.66 22.99,82.15 22.99,86.98 22.7,87.26 22.34,87.26 17.47,87.26 16.41,88.32 16.41,92.23 15.62,93.02 15.62,97.84 15.31,98.15 15.31,98.6 v2(15.26,98.66)
  IN2 w0.124: v2(15.26,98.66) 15.37,98.78 15.37,99.47 15.52,99.62 15.52,103.67 16.62,104.78 16.62,105.86 v2(16.5,105.98)
  BOTTOM w0.112: v2(16.5,105.98) 16.63,106.11 16.63,106.27 16.32,106.58 15.93,106.58 RT123.2
TBTA_BOT_P_R: length 8.7
  BOTTOM w0.112: JUSBC1.B6 6.93,107.08 10.3,107.08 10.54,106.85 v4(11.2,106.85) 12.09,106.85 12.38,106.56 13.64,106.56 DT19.1 14.09,106.56 14.37,106.56 RT123.1
TBTA_CC1: length 50.9
  TOP w0.127: 28.4,79.26 28.57,79.43 28.97,79.43 UT5.L9
  TOP w0.203: 28.4,79.26 28.21,79.07 26.3,79.07 25.92,78.69 RT104.2
  TOP w0.305: JUSBC1.A5 10.56,107.9 10.78,107.68 DT7.1 12.74,107.52 v2(13.21,107.52) ; v2(21.23,78.24) 21.23,78.4 21.97,79.13 24.55,79.13 CT86.1 RT104.2
  IN1 w0.305: v2(13.18,99.53) 12.7,99.05 12.7,96.07 13.42,95.35 13.42,91.71 14.19,90.94 14.19,82.43 14.22,82.4 14.22,82.38 18.85,77.76 20.88,77.76 21.23,78.12 v2(21.23,78.24)
  IN2 w0.305: v2(13.18,99.53) 12.91,99.79 12.91,107.22 v2(13.21,107.52)
  BOTTOM w0.102: v2(13.18,99.53) v3(12.15,99.53)
TBTA_CC2: length 51.6
  TOP w0.203: UT5.L10 28.8,78.97 28.27,78.45 27.6,78.45 27.2,78.05 26.3,78.05 25.92,77.67 RT105.2
  TOP w0.305: v2(21.87,78.24) 21.87,77.94 22.9,76.91 24.6,76.91 25.06,77.37 CT85.1 RT105.2
  IN1 w0.305: v2(14.04,98.77) 14.04,96.19 14.43,95.81 14.43,92.25 14.43,92.24 14.43,92.03 15.1,91.36 15.1,91.11 15.1,82.81 18.01,79.89 19.05,79.89 19.23,79.72 21.08,79.72 21.87,78.93 v2(21.87,78.24)
  IN2 w0.305: v2(15.33,104.51) 13.9,103.08 13.9,100.38 14.55,99.73 14.55,99.27 v2(14.04,98.77)
  BOTTOM w0.127: 7.09,106.27 5.88,106.27 JUSBC1.B5
  BOTTOM w0.305: 7.09,106.27 7.25,106.44 10.06,106.44 10.25,106.25 11.64,106.25 v1(13.26,104.63) DT16.1 15.2,104.63 v2(15.33,104.51)
TBTA_DBG_CTL1: length 5.8
  TOP w0.076: v2(32.1,82.46) 32.02,82.38 UT5.E4
  BOTTOM w0.112: RT106.1 29.82,85.71 v1(29.82,85.02) 29.82,84.19 30.11,83.91 31.32,83.91 32.1,83.12 v2(32.1,82.46)
TBTA_DBG_CTL2: length 2.3
  TOP w0.076: UT5.D5 32.95,81.9 v2(32.99,81.9)
  BOTTOM w0.112: v2(32.99,81.9) 33.6,81.9 RT107.1 v1(34.61,81.91)
TBTA_DEBUG1: length 3.3
  TOP w0.076: UT5.L2 28.95,83.05 28.44,83.05 27.93,83.56
  TOP w0.112: 27.93,83.56 27.67,83.82 27.21,83.82 26.39,84.64 RT92.2
TBTA_DEBUG2: length 4.5
  TOP w0.076: UT5.K2 29.27,83.22 28.55,83.22 28.12,83.65 28.12,83.75 27.93,83.94
  TOP w0.112: RT93.2 26.85,85.09 26.85,84.63 27.27,84.21 27.48,84.21 27.66,84.03 27.84,84.03 27.93,83.94
TBTA_DEBUG3: length 6.6
  TOP w0.076: 27.93,82.88 27.96,82.84 28.14,82.84 28.3,82.69 28.7,82.69 28.84,82.55 28.95,82.55 UT5.L3
  TOP w0.112: 27.93,82.88 27.53,83.27 26.31,83.27 26.19,83.39 24.45,83.39 24.13,83.07 24.13,82.86 v2(24.25,82.74)
  BOTTOM w0.112: v2(24.25,82.74) 24.08,82.56 24.08,82.21 RT89.2
TBTA_DEBUG4: length 7.6
  TOP w0.076: 27.93,83.2 28.1,83.02 28.22,83.02 28.37,82.87 28.77,82.87 28.92,82.72 29.27,82.72 UT5.K3
  TOP w0.112: 27.93,83.2 27.64,83.49 26.57,83.49 26.45,83.61 24.36,83.61 23.85,83.09 23.85,82.84 v2(23.67,82.66)
  BOTTOM w0.112: RT90.2 23.49,82.23 23.49,82.48 v2(23.67,82.66)
TBTA_HPD: length 26.7
  TOP w0.102: UT1.M4 v2(29.04,98.04)
  BOTTOM w0.112: RT73.1 28.22,78.75 v1(26.57,80.4) 26.25,80.72 26.25,86.71 26.69,87.16 26.69,88.53 28.4,90.23 28.4,91.08 28.8,91.49 28.8,93.02 26.82,95.01 26.82,95.94 27.18,96.3 27.95,96.3 28.38,96.73 RT23.1 29.04,96.92 v2(29.04,98.04)
TBTA_HPD_R: length 2
  TOP w0.102: UT5.C10 v2(33.02,79.45)
  BOTTOM w0.112: RT73.2 32.4,78.75 v1(32.7,79.05) 33.02,79.37 v2(33.02,79.45)
TBTA_I2C_INT: length 28.8
  TOP w0.076: 33.64,84.51 33.64,84.43 33.02,83.81 UT5.C1
  TOP w0.102: UT1.J4 v2(27.74,98.04)
  TOP w0.112: v2(33.39,87.91) 33.39,87.74 33.77,87.36 33.77,85.02 33.64,84.89 33.64,84.51
  IN1 w0.119: v2(27.74,98.04) 29.11,96.66 30.4,96.66 31.82,95.24 33.39,95.24 34.38,94.24 35.32,94.24 35.84,93.73 35.84,92.32 34.31,90.79 34.31,88.83 v2(33.39,87.91)
  BOTTOM w0.112: v2(27.74,98.04) 25.98,96.28 25.98,94.65 v1(26.36,94.27) 27.71,92.92 RT16.1
TBTA_LSRX: length 29.4
  TOP w0.102: v2(22.19,98.82) 22.36,98.99 23.02,98.99 24.09,97.93 UT1.A4
  TOP w0.112: RT21.1 21.69,98.82 v2(22.19,98.82) ; v2(23.49,80.48) 23.65,80.64 23.65,81.61 24.1,82.06 24.59,82.06 RT88.1
  IN3 w0.135: v2(22.19,98.82) 22.01,98.99 21.83,98.99 21.69,98.86 21.69,91.32 20.55,90.18 20.55,81.54 22.07,80.02 23.45,80.02 23.62,80.19 23.62,80.35 v2(23.49,80.48)
  BOTTOM w0.112: RT90.1 23.52,80.96 23.52,80.51 v2(23.49,80.48)
TBTA_LSRX_R: length 4.3
  TOP w0.076: 27.53,82.58 27.98,82.58 28.04,82.51 28.63,82.51 28.77,82.37 28.77,82.37 28.92,82.22 29.27,82.22 UT5.K4
  TOP w0.112: RT88.2 26.12,82.07 26.23,82.07 26.74,82.58 27.53,82.58
TBTA_LSTX: length 30.2
  TOP w0.102: UT1.A5 23.99,98.39 23.13,99.25 22.39,99.25 v2(22.19,99.45)
  TOP w0.112: v2(22.19,99.45) 21.69,99.45 RT22.1 ; v2(24.07,80.48) 23.91,80.64 23.91,81.5 24.21,81.79 24.59,81.79 RT87.1
  IN3 w0.135: v2(22.19,99.45) 22.01,99.28 21.71,99.28 21.41,98.97 21.41,91.43 20.27,90.3 20.27,81.42 21.95,79.74 23.57,79.74 23.91,80.07 23.91,80.32 v2(24.07,80.48)
  BOTTOM w0.112: RT89.1 24.07,81 v2(24.07,80.48)
TBTA_LSTX_R: length 3.7
  TOP w0.076: 27.53,82.31 27.54,82.31 27.56,82.33 27.63,82.33 27.65,82.35 27.88,82.35 27.95,82.28 28.53,82.28 28.68,82.14 28.68,82.14 28.82,81.99 29,81.99 UT5.L4
  TOP w0.112: RT87.2 26.14,81.8 26.34,81.8 26.85,82.31 27.53,82.31
TBTA_MRESET: length 2.2
  TOP w0.076: UT5.E11 32.02,77.31
  TOP w0.112: 32.02,77.31 32.02,77.14 31.96,77.09 31.96,76.41 RT86.1
TBTA_RESET_N_EC_R: length 2.4
  TOP w0.076: UT5.F11 31.52,77.49 31.34,77.31
  TOP w0.112: 31.34,77.31 31.16,77.13 31.16,76.62 RT110.1
TBTA_ROM_CLK_PD: length 21.3
  TOP w0.112: RT54.2 28.97,71.77 v2(28.6,71.77) ; v2(36.55,83.2) 35.88,82.53 35.29,82.53 35.13,82.36 34.59,82.36 34.48,82.47 UT5.A3
  IN1 w0.119: v2(36.55,83.2) 36.03,83.2 35.25,82.42 35.25,75.88 33.46,74.09 31.23,74.09 30.86,73.72 29.33,73.72 28.43,72.82 28.43,72.82 28.18,72.57 28.18,72.57 28.14,72.53 28.14,72.22 v2(28.6,71.77)
TBTA_ROM_CLK_PD_R: length 10.3
  TOP w0.112: v2(31.09,71.51) RT54.1
  BOTTOM w0.102: 32.29,71.13 v3(33.81,71.13)
  BOTTOM w0.112: JDB1.2 29.88,68.51 29.42,68.96 29.42,71.19 29.74,71.51 v2(31.09,71.51) 31.47,71.13 32.29,71.13
TBTA_ROM_CS#_PD: length 28.1
  TOP w0.076: UT5.B3 33.77,82.72 34.56,82.72 34.67,82.61 34.9,82.61 35.03,82.74 35.11,82.74
  TOP w0.102: v2(27.49,67.83) v1(27.49,66.79)
  TOP w0.112: RT57.2 27.98,68.48 27.49,67.99 v2(27.49,67.83) ; v2(36.55,83.78) 36.09,83.32 36.09,83.09 35.74,82.74 35.11,82.74
  IN1 w0.119: v2(27.49,67.83) 27.49,72.31 28.14,72.95 28.14,72.95 28.38,73.19 28.38,73.2 29.19,74 30.76,74 31.1,74.34 33.31,74.34 35,76.03 35,82.8 35.98,83.78 v2(36.55,83.78)
TBTA_ROM_CS#_PD_R: length 10.1
  TOP w0.112: RT51.1 RT57.1 26.63,68.59 v2(26.11,69.11) v1(26.11,67)
  BOTTOM w0.112: JDB1.5 28.38,67.26 28.56,67.45 28.56,68.25 27.7,69.11 v2(26.11,69.11) 26.11,68.82 25.88,68.59 UT6.1
TBTA_ROM_DI_PD: length 19.9
  TOP w0.076: UT5.B4 33.77,82.22 34.42,82.22 34.54,82.1 35.11,82.1
  TOP w0.112: RT55.2 v2(28.6,72.4) ; 35.11,82.1 35.33,82.1 35.41,82.18 36.12,82.18 v2(36.55,82.61)
  IN1 w0.119: v2(36.55,82.61) 36.02,82.61 35.51,82.1 35.51,75.75 33.59,73.84 31.33,73.84 29.89,72.4 v2(28.6,72.4)
TBTA_ROM_DI_PD_R: length 11
  TOP w0.112: v2(31.09,72.25) 30.94,72.4 RT55.1
  BOTTOM w0.102: UT6.5 33.23,72.4 v3(33.81,72.97)
  BOTTOM w0.112: UT6.5 31.23,72.4 31.09,72.26 v2(31.09,72.25) 30.1,72.25 29.17,71.32 29.17,68.78 29.38,68.57 JDB1.3
TBTA_ROM_DO_PD: length 20
  TOP w0.102: v2(36.55,82.03) 36.32,82.03 36.14,81.85 34.44,81.85 34.32,81.97 UT5.A4
  TOP w0.112: v2(28.6,71.13) 28.29,71.13 RT56.2
  IN1 w0.119: v2(36.55,82.03) 36.1,82.03 35.76,81.69 35.76,75.65 33.65,73.54 31.39,73.54 28.98,71.13 v2(28.6,71.13)
  BOTTOM w0.112: v2(36.55,82.03) v1(36.55,81.39)
TBTA_ROM_DO_PD_R: length 10.7
  TOP w0.112: v2(26.07,70.5) RT52.1 RT56.1
  BOTTOM w0.102: v3(23.58,69.04) 24.41,69.86 UT6.2
  BOTTOM w0.112: JDB1.4 28.88,68.47 26.85,70.5 v2(26.07,70.5) 26.07,70.06 25.87,69.86 UT6.2
TBTA_ROM_HOLD#_PD: length 4.9
  TOP w0.112: RT50.1 30.73,70.5 v2(31.09,70.85)
  BOTTOM w0.102: v3(33.81,69.29) 33.23,69.86 UT6.7
  BOTTOM w0.112: v2(31.09,70.85) 31.09,70.15 31.38,69.86 UT6.7
TBTA_ROM_WP#_PD: length 2.9
  TOP w0.112: RT53.1 26.64,72.4 v2(26.08,71.84)
  BOTTOM w0.112: 25.04,71.13 25.91,71.13 26.08,71.31 v2(26.08,71.84)
TBTA_ROSC: length 4.5
  TOP w0.076: UT5.G2 30.77,83.22 30.77,84.15 30.86,84.24 30.86,84.51
  TOP w0.112: v2(30.43,85.29) 30.43,85.18 30.86,84.75 30.86,84.51
  BOTTOM w0.112: RT100.1 30.43,85.96 v2(30.43,85.29) 30.89,84.83 v1(30.89,84.3)
TBTA_RX1N: length 21.2
  TOP w0.076: 23.79,105.65 23.97,105.65 arc(24.01,105.64) 24.05,105.61 arc(24.15,105.55) 24.27,105.52 24.32,105.52 arc(24.4,105.54) 24.46,105.58 arc(24.48,105.66) 24.44,105.74 24.43,105.75 UT1.A21
  TOP w0.175: 23.79,105.65 23.77,105.65 arc(23.35,105.73) 23,105.97 22.17,106.79 22.15,106.79 arc(22.12,106.82) 22.09,106.84 arc(21.96,106.91) 21.83,106.93 20.63,106.93 arc(20.42,106.89) v2(20.24,106.77)
  BOTTOM w0.175: JUSBC1.B10 arc(6.03,108.96) 6.34,109.04 6.95,109.04 arc(7.2,109.09) 7.41,109.24 7.5,109.32 arc(7.61,109.4) 7.75,109.42 10.13,109.42 arc(10.4,109.48) 10.62,109.63 10.78,109.78 arc(10.94,109.89) 11.12,109.92 11.28,109.92 arc(11.47,109.89) 11.63,109.78 DT14.1 11.77,109.76 arc(11.96,109.89) 12.2,109.94 14.96,109.94 arc(15.65,109.8) 16.24,109.4 18.41,107.23 arc(18.74,107.01) 19.13,106.94 19.91,106.94 arc(20.1,106.89) v2(20.24,106.77)
TBTA_RX1P: length 21.2
  TOP w0.076: UT1.B21 24.63,105.88 arc(24.53,105.95) 24.41,105.97 24.21,105.97 arc(24.18,105.97) 24.14,105.97 arc(24.09,105.95) 24.04,105.92 23.79,105.92
  TOP w0.175: 23.79,105.92 23.76,105.92 arc(23.45,105.98) 23.18,106.16 22.28,107.06 22.24,107.06 arc(22.05,107.16) 21.83,107.19 20.63,107.19 arc(20.42,107.23) v2(20.24,107.35)
  BOTTOM w0.175: JUSBC1.B11 arc(6.01,109.37) 6.29,109.31 6.95,109.31 arc(7.1,109.34) 7.23,109.42 7.31,109.51 arc(7.51,109.64) 7.75,109.69 10.13,109.69 arc(10.3,109.72) 10.44,109.82 10.59,109.97 arc(10.83,110.13) 11.12,110.19 11.38,110.19 arc(11.48,110.21) 11.55,110.26 DT13.1 arc(11.91,110.26) 12.15,110.2 14.96,110.2 arc(15.75,110.04) 16.43,109.59 18.6,107.42 arc(18.84,107.26) 19.13,107.2 19.91,107.2 arc(20.09,107.24) v2(20.24,107.35)
TBTA_RX2N: length 20.9
  TOP w0.076: UT1.B15 24.68,103.07 arc(24.52,103.18) 24.34,103.21 24.23,103.21 arc(24.14,103.2) 24.06,103.15 24.01,103.1 arc(23.99,103.08) 23.96,103.07 arc(23.96,103.07) 23.95,103.07 arc(23.93,103.07) 23.91,103.07 arc(23.84,103.06) 23.77,103.04
  TOP w0.175: JUSBC1.A10 8.28,105.4 8.28,105.4 arc(8.41,105.31) 8.56,105.28 9.44,105.28 arc(9.95,105.07) 10.16,104.57 10.16,103.69 arc(10.28,103.39) 10.59,103.27 11.28,103.27 arc(11.41,103.29) 11.52,103.37 DT9.1 11.74,103.4 arc(11.89,103.3) 12.06,103.26 15.16,103.26 15.59,103.29 arc(15.97,103.47) 16.26,103.76 arc(16.73,104.2) 17.35,104.35 18.53,104.35 arc(19.33,104.02) 19.66,103.23 19.66,102.95 arc(19.93,102.3) 20.58,102.03 22.17,102.03 arc(22.64,102.12) 23.03,102.39 23.55,102.9 arc(23.65,102.98) 23.77,103.04
TBTA_RX2P: length 20.9
  TOP w0.076: 23.77,102.7 23.87,102.79 arc(23.89,102.82) 23.93,102.83 23.96,102.83 arc(23.97,102.83) 23.97,102.83 arc(24.02,102.82) 24.06,102.81 arc(24.12,102.77) 24.19,102.75 24.38,102.75 arc(24.43,102.76) 24.47,102.79 24.49,102.81 arc(24.52,102.87) 24.49,102.94 24.47,102.96 arc(24.43,102.98) 24.39,102.99 UT1.A15
  TOP w0.175: 23.77,102.7 23.31,102.24 arc(22.79,101.89) 22.17,101.77 20.58,101.77 arc(19.74,102.11) 19.39,102.95 19.39,103.23 arc(19.14,103.84) 18.53,104.09 17.35,104.09 arc(16.85,103.96) 16.48,103.62 16.48,103.61 arc(16.11,103.24) 15.64,103.03 15.17,103 12.17,103 arc(11.89,102.94) DT10.1 11.52,102.9 arc(11.47,102.94) 11.42,102.97 arc(11.35,103) 11.28,103 10.59,103 arc(10.1,103.21) 9.89,103.69 9.89,104.57 arc(9.76,104.89) 9.44,105.02 8.56,105.02 arc(8.44,105) 8.35,104.93 8.32,104.9 JUSBC1.A11
TBTA_SBU1: length 47.9
  TOP w0.112: v2(20.6,78.24) 21.8,79.44 25.39,79.44 RT108.2 ; v2(15.33,105.1) 14.86,104.63 DT8.1 13.23,104.63 11.68,106.18 10.16,106.18 10.01,106.34 8.58,106.34 8.52,106.4 JUSBC1.A8
  IN1 w0.119: v2(14.04,99.5) 13.61,99.07 13.61,96.18 14.06,95.73 14.06,91.96 14.78,91.24 14.78,82.66 18.77,78.67 19.76,78.67 20.39,79.31 20.83,79.31 21.06,79.08 21.06,78.7 v2(20.6,78.24)
  IN2 w0.124: v2(15.33,105.1) 13.59,103.36 13.59,100.16 14.04,99.71 v2(14.04,99.5)
  BOTTOM w0.112: v2(14.04,99.5) 14.04,99.85 v3(13.8,100.09)
TBTA_SBU1_R: length 3.3
  TOP w0.076: UT5.K8 29.27,79.72 28.89,79.72 28.79,79.63 28.48,79.63 28.37,79.51 27.93,79.51
  TOP w0.112: RT108.1 26.5,79.51 27.93,79.51
TBTA_SBU2: length 48.9
  TOP w0.112: RT109.2 25.53,80.39 24.79,79.66 21.38,79.66 v2(20.6,78.88)
  IN1 w0.119: v2(13.18,98.77) 13.18,96.07 13.84,95.42 13.84,91.87 13.84,91.86 13.84,91.73 14.5,91.07 14.5,82.56 18.67,78.4 20.12,78.4 v2(20.6,78.88)
  IN2 w0.124: v2(13.21,108.1) 13.28,108.1 13.65,107.73 13.65,107.3 13.3,106.94 13.3,100.05 13.61,99.73 13.61,99.2 v2(13.18,98.77)
  BOTTOM w0.102: v2(13.18,98.77) 13.18,98.11 v3(13.23,98.05)
  BOTTOM w0.112: JUSBC1.B8 5.87,108.02 7.07,108.02 7.19,107.91 10.62,107.91 10.84,107.68 DT15.1 12.79,107.68 v2(13.21,108.1)
TBTA_SBU2_R: length 3
  TOP w0.076: 27.93,79.77 28.37,79.77 28.41,79.81 28.72,79.81 28.88,79.97 UT5.L8
  TOP w0.112: RT109.1 26.72,80.19 27.02,80.19 27.44,79.77 27.93,79.77
TBTA_TOP_N: length 47.1
  TOP w0.076: 27.84,80.95 27.94,80.95 29,80.95 UT5.L6
  TOP w0.112: v2(16.93,107.21) 16.77,107.05 16.77,106.68 16.5,106.42 15.77,106.42 RT121.1 ; 27.84,80.95 27.8,80.99 27.63,80.99 27.33,81.29 v2(27.33,81.34)
  IN1 w0.119: v2(27.33,81.34) 26.95,81.72 26.95,81.8 24.12,84.63 24.12,87.5 23.22,88.4 18.13,88.4 17.55,88.99 17.55,92.8 16.89,93.45 16.89,96.63 18.34,98.08 18.34,99.09 18.07,99.35 17.34,99.35 v2(17.32,99.37)
  IN2 w0.124: v2(16.93,107.21) 16.93,107.01 16.4,106.49 15.48,106.49 14.79,107.17 14.79,107.93 15.55,108.69 16.94,108.69 17.97,107.65 17.97,104.4 16.79,103.21 16.79,99.9 v2(17.32,99.37)
TBTA_TOP_N_R: length 7.4
  TOP w0.112: RT121.2 14.37,106.56 14.09,106.56 DT12.1 13.65,106.55 12.36,106.55 12.18,106.73 10.33,106.73 10.04,107.02 8.6,107.02 8.48,106.9 JUSBC1.A7
TBTA_TOP_P: length 47.1
  TOP w0.076: UT5.K6 29.27,80.72 28.04,80.72 27.99,80.72 27.95,80.69 27.73,80.69 27.7,80.72
  TOP w0.112: 27.7,80.72 27.69,80.73 27.52,80.73 27.34,80.91 27.14,80.91 v2(26.69,81.35) ; RT120.1 15.59,107.03 15.94,106.68 16.39,106.68 16.5,106.79 16.5,107.19 16.39,107.3 v2(16.22,107.3)
  IN1 w0.119: v2(17.31,98.78) 17.32,98.78 17.64,99.1 17.96,99.1 18.08,98.98 18.08,98.18 16.64,96.74 16.64,93.35 17.3,92.69 17.3,88.88 18.03,88.15 23.11,88.15 23.87,87.39 23.87,84.52 26.69,81.7 v2(26.69,81.35)
  IN2 w0.124: v2(17.31,98.78) 17.05,98.78 16.84,98.99 16.84,99.44 16.5,99.78 16.5,103.34 17.68,104.52 17.68,107.53 16.81,108.39 15.67,108.39 15.09,107.8 15.09,107.3 15.6,106.78 16.28,106.78 16.48,106.99 16.48,107.17 16.36,107.3 v2(16.22,107.3)
TBTA_TOP_P_R: length 7.4
  TOP w0.112: JUSBC1.A6 8.48,107.4 8.6,107.28 10.15,107.28 10.44,107 12.29,107 12.47,106.82 13.64,106.82 DT11.1 14.09,106.82 14.37,106.82 RT120.2
TBTA_TX1N: length 3.6
  TOP w0.076: UT1.B19 24.76,104.83 24.76,104.83 24.58,104.65 arc(24.53,104.62) 24.47,104.61 24.2,104.61 arc(24.09,104.63) 23.99,104.7 arc(23.97,104.7) 23.95,104.7 23.91,104.7
  TOP w0.175: 23.91,104.7 23.37,104.7 arc(22.98,104.78) 22.66,104.99 22.66,104.99 arc(22.44,105.14) 22.17,105.19 21.74,105.19 arc(21.55,105.16) CT96.1
TBTA_TX1N_C: length 17.2
  TOP w0.175: JUSBC1.A3 8.25,108.9 8.29,108.94 arc(8.38,109) 8.48,109.02 9.48,109.02 arc(9.81,109.08) 10.09,109.27 10.57,109.76 arc(10.76,109.88) 10.98,109.92 11.25,109.92 arc(11.47,109.88) 11.65,109.76 DT6.1 11.77,109.76 arc(11.95,109.88) 12.17,109.92 16.74,109.92 arc(17.65,109.54) 18.03,108.63 18.03,106.48 arc(18.4,105.58) 19.3,105.21 20.44,105.21 arc(20.64,105.17) CT96.2
TBTA_TX1P: length 3.7
  TOP w0.076: UT1.A19 24.41,104.83 arc(24.47,104.85) 24.49,104.91 24.49,104.95 arc(24.46,105.03) 24.38,105.06 24.13,105.06 arc(24.07,105.05) 24.01,105.02 23.96,104.96 23.86,104.96
  TOP w0.175: CT95.1 21.44,105.58 arc(21.58,105.49) 21.74,105.46 22.17,105.46 arc(22.54,105.39) 22.85,105.18 arc(23.09,105.02) 23.37,104.96 23.51,104.96 23.86,104.96
TBTA_TX1P_C: length 17.1
  TOP w0.175: JUSBC1.A2 8.24,109.4 8.27,109.37 arc(8.37,109.31) 8.48,109.28 9.48,109.28 arc(9.71,109.33) 9.9,109.46 10.39,109.94 arc(10.66,110.12) 10.98,110.19 11.25,110.19 arc(11.47,110.23) 11.65,110.35 DT5.1 11.77,110.35 arc(11.95,110.23) 12.17,110.19 16.74,110.19 arc(17.84,109.73) 18.3,108.63 18.3,106.48 arc(18.59,105.77) 19.3,105.47 20.44,105.47 arc(20.64,105.51) CT95.2
TBTA_TX2N: length 3.7
  TOP w0.076: UT1.B17 24.76,103.91 24.66,104.01 arc(24.52,104.1) 24.35,104.13 24.19,104.13 arc(24.1,104.11) 24.02,104.06 arc(23.92,104.02) 23.82,104.01 23.77,104.01
  TOP w0.175: 23.77,104.01 23.47,104.01 arc(23.3,103.98) 23.16,103.88 23.16,103.88 arc(23,103.77) 22.82,103.74 22.57,103.74 arc(22.36,103.78) v2(22.19,103.9)
  BOTTOM w0.175: v2(22.19,103.9) 22.15,103.86 arc(22.02,103.77) 21.87,103.74 21.77,103.74 arc(21.57,103.78) CT98.1
TBTA_TX2N_C: length 17.4
  BOTTOM w0.175: JUSBC1.B3 arc(6.08,105.32) 6.42,105.24 7.28,105.24 arc(7.9,105.12) 8.42,104.77 9.67,103.52 arc(9.95,103.34) 10.27,103.27 11.21,103.27 arc(11.45,103.33) DT18.1 11.72,103.41 arc(11.88,103.3) 12.07,103.26 arc(12.08,103.26) 12.09,103.26 14.68,103.26 arc(14.84,103.29) 14.98,103.39 arc(15.35,103.63) 15.78,103.72 15.91,103.72 arc(16.28,103.79) 16.59,104 17.39,104.8 arc(17.68,105) 18.03,105.07 19.02,105.07 arc(19.69,104.79) 19.96,104.13 19.96,104.1 arc(20.07,103.85) 20.32,103.74 20.51,103.74 arc(20.68,103.78) CT98.2
TBTA_TX2P: length 3.7
  TOP w0.076: 23.77,103.75 24,103.75 arc(24.05,103.74) 24.11,103.72 arc(24.17,103.68) 24.24,103.67 24.32,103.67 arc(24.4,103.68) 24.46,103.73 arc(24.49,103.77) 24.5,103.81 arc(24.49,103.87) 24.46,103.91 24.46,103.91 UT1.A17
  TOP w0.175: v2(22.19,103.31) 22.27,103.4 arc(22.35,103.45) 22.45,103.47 arc(22.47,103.47) 22.48,103.47 22.82,103.47 arc(23.1,103.53) 23.34,103.69 23.35,103.7 arc(23.41,103.73) 23.47,103.75 23.77,103.75
  BOTTOM w0.175: v2(22.19,103.31) 22.13,103.37 arc(22.01,103.45) 21.87,103.48 21.77,103.48 arc(21.57,103.44) CT97.1
TBTA_TX2P_C: length 17.4
  BOTTOM w0.175: CT97.2 arc(20.67,103.44) 20.49,103.48 20.32,103.48 arc(19.88,103.66) 19.7,104.1 19.7,104.13 arc(19.5,104.6) 19.02,104.8 18.03,104.8 arc(17.78,104.75) 17.57,104.61 16.78,103.82 arc(16.38,103.55) 15.91,103.45 15.78,103.45 arc(15.45,103.39) 15.17,103.2 arc(14.95,103.05) 14.68,103 12.09,103 arc(11.88,102.96) 11.7,102.84 DT17.1 arc(11.52,102.94) 11.33,103.01 10.27,103.01 arc(9.85,103.09) 9.48,103.33 8.24,104.58 arc(7.8,104.88) 7.28,104.98 6.26,104.98 arc(6,104.92) JUSBC1.B2
TBTA_USB2_RBIAS: length 3.1
  TOP w0.112: UT1.H19 v2(27.74,105.19)
  BOTTOM w0.112: v2(27.74,105.19) 27.65,105.19 26.74,106.09 RT41.1 26.74,106.61 v1(27.28,107.15)
TBTA_USB20_N: length 42.6
  TOP w0.076: UT5.K5 29.11,81.22 28.74,81.22 v2(28.34,81.33) ; UT1.D20 v2(25.79,105.19)
  IN3 w0.135: v2(25.79,105.19) 25.06,104.46 25.06,101.06 24.22,100.22 21.32,100.22 20.48,99.37 20.48,91.86 18.66,90.04 18.66,80.28 19.18,79.77 20.39,79.77 21.36,78.8 25.06,78.8 26.88,80.62 27.63,80.62 v2(28.34,81.33)
TBTA_USB20_P: length 42.6
  TOP w0.076: UT5.L5 28.94,81.47 28.87,81.55 28.87,81.71 28.79,81.79 28.61,81.79 28.54,81.71 28.29,81.71 v2(28.11,81.89) ; UT1.E20 v2(26.44,105.19)
  IN3 w0.135: v2(28.11,81.89) 27.92,81.7 27.92,81.31 27.51,80.91 26.77,80.91 24.94,79.08 21.48,79.08 20.5,80.05 19.3,80.05 18.95,80.4 18.95,89.93 20.76,91.74 20.76,99.26 21.44,99.93 24.34,99.93 25.35,100.94 25.35,104.34 25.77,104.76 26.02,104.76 26.2,104.95 26.3,104.95 26.44,105.09 v2(26.44,105.19)
TBTB_HPD: length 5.3
  TOP w0.076: UT1.G2 27.06,97 27.28,96.79 27.28,96.26 26.95,95.93 26.95,95.13 27.2,94.88
  TOP w0.112: 27.2,94.88 28.97,93.11 RT33.1
TBTB_I2C_INT: length 4.6
  TOP w0.076: UT1.E2 26.37,96.78 26.37,96.31 26.24,96.18 26.24,95.24 26.03,95.03 26.03,94.88
  TOP w0.112: RT17.1 25.93,92.86 25.93,93.81 26.03,93.91 26.03,94.88
TBTB_LSRX: length 4.4
  TOP w0.076: UT1.B5 24.76,98.4 24.54,98.63 24.09,98.63 23.95,98.77 23.95,99.4 23.77,99.58
  TOP w0.112: 23.77,99.58 23.14,100.21 21.82,100.21 RT32.1
TBTB_LSTX: length 5.9
  TOP w0.076: UT1.B4 24.53,97.7 23.94,97.7 23.68,97.95 23.41,97.95
  TOP w0.112: RT31.1 19.89,98.18 22.5,98.18 22.73,97.95 23.41,97.95
TBTB_USB2_RBIAS: length 5.5
  TOP w0.112: UT1.F19 v2(26.44,104.54)
  BOTTOM w0.112: v1(26.47,108.35) 26.47,106.94 25.44,105.92 RT42.1 25.36,105.85 25.36,105 25.58,104.79 26.19,104.79 v2(26.44,104.54)
TDI_XDP: length 17.5
  TOP w0.112: v2(80.77,120.48) 80.77,120.54 v1(82.51,122.28) 82.51,123.91 83.61,125.01 84.44,125.01 87.25,127.82 87.25,130.45 87.01,130.69 v2(87.01,132.22)
  BOTTOM w0.112: UC8.5 80.8,120.57 80.77,120.54 v2(80.77,120.48) 80.67,120.37 RC229.1 ; JXDP1.56 v2(87.01,132.22)
TDO_XDP: length 19.8
  TOP w0.112: v2(88.21,132.22) 88.21,131.16 CC306.1 87.68,130.54 87.68,129.78 87.98,129.48 89.16,129.48 89.55,129.09 89.55,128.44 89.08,127.97 88.06,127.97 84.48,124.38 84.48,121.54 v1(83.99,121.05) 83.39,120.45 v2(82.89,120.45)
  BOTTOM w0.112: UC8.2 82.3,120.93 82.72,120.52 82.83,120.52 v2(82.89,120.45) RC230.1 ; JXDP1.52 v2(88.21,132.22)
TDOCK_BATLOW#: length 5.1
  TOP w0.076: 26.54,94.88 26.54,95.01 26.59,95.06 26.59,96.04 26.82,96.27 26.82,96.8 UT1.F2
  TOP w0.112: RT20.1 27.98,93.33 26.54,94.76 26.54,94.88
TEST_EN: length 4.2
  TOP w0.076: 25.78,94.88 25.78,95.11 26.02,95.36 26.02,96.21 26.14,96.33 UT1.E1
  TOP w0.112: RT36.1 25.65,93.22 25.65,94.16 25.78,94.28 25.78,94.88
TEST_PWRGD: length 2.9
  TOP w0.076: UT1.AB5 34.19,98.16 34.97,98.16 35.35,97.78
  TOP w0.112: 35.35,97.78 35.41,97.72 35.84,97.72 36.33,97.23 RT37.1
THERMATRIP1#: length 4.1
  TOP w0.107: UE1.B12 247.08,93.06 247.08,93.69 246.66,94.12 246.66,95.13 v1(246.79,95.26) 247.17,95.64 RE301.1
THERMATRIP2#: length 36
  TOP w0.107: UE1.H3 v2(252.68,85.06)
  TOP w0.112: v1(262.89,101.56) 263.19,101.86 v2(263.42,101.86) QE4.1 CE36.1 RE69.2
  IN1 w0.119: v2(252.68,85.06) 252.22,85.52 252.22,92.37 252.73,92.87 252.73,96.23 253.11,96.61 253.11,98.84 252.82,99.13 252.82,102.26 254.84,104.28 261.01,104.28 v2(263.42,101.86)
THERMDA: length 0.5
  TOP w0.127: UT1.AC23 UT1.AB23
TOUCH_SCREEN_DET#: length 159.6
  TOP w0.112: v2(63.78,123.28) 63.78,123.07 63.5,122.79 62.83,122.79 61.96,123.66 61.96,132.84 RV8.1 61.49,134 61.75,134.25 v1(63.91,134.25) 65.56,134.25 v2(66,133.81)
  IN1 w0.119: v2(74.26,85.93) 74.84,85.34 80.2,85.34 88.27,77.28 122.31,77.28 126.89,81.86 131.13,81.86 131.47,81.52 131.47,79.03 131.72,78.78 135.71,78.78 137.46,80.53 137.95,80.53 138.39,80.97 138.39,81.61 138.26,81.74 138.26,86.37 136.61,88.02 136.61,88.85 v2(136.04,89.42)
  IN2 w0.124: v2(74.26,85.93) 74.26,93.19 73.35,94.09 73.35,103.31 72.49,104.18 71.53,104.18 70.76,104.94 70.76,111.01 70.31,111.47 62.56,111.47 60.67,113.36 60.67,115.33 62,116.66 62,119.39 63.78,121.17 v2(63.78,123.28)
  BOTTOM w0.076: 135.55,89.42 135.02,89.42 134.34,90.11 130.78,90.11 130.3,90.59 130.3,90.97 130.15,91.12 130.15,91.63 129.76,92.01 UC1.AY5
  BOTTOM w0.112: 135.55,89.42 v2(136.04,89.42) ; JEDP1.32 66.75,133.37 66.32,133.81 v2(66,133.81)
TOUCH_SCREEN_PD#: length 105.1
  IN2 w0.124: v2(131.73,118.15) 131.41,118.15 130.83,118.72 130.83,121.07 132.1,122.33 132.1,123.04 131.76,123.38 128.93,123.38 128.62,123.69 120.83,123.69 119.97,124.55 119.31,124.55 119.14,124.38 118.07,124.38 116.81,123.12 109.93,123.12 109.68,122.87 103.73,122.87 102.77,123.84 98.99,123.84 98.02,122.86 89.47,122.86 88.62,122.01 86.71,122.01 86.62,122.1 86.02,122.1 84.96,121.04 65.35,121.04 64.41,121.98 v2(64.41,123.28)
  BOTTOM w0.102: 131.13,115.73 128.89,113.49 UC1.A7
  BOTTOM w0.107: JEDP1.5 53.25,129.86 53.69,129.42 53.69,126.66 55.55,124.8 62.89,124.8 v1(63.36,124.33) v2(64.41,123.28)
  BOTTOM w0.112: 131.13,115.73 132.66,117.26 RC272.1 132.53,118.95 v2(131.73,118.15)
TOUCHPAD_INTR#: length 163.3
  TOP w0.112: RC414.1 135.72,85.86 v2(132.7,88.88) ; v2(249.52,74.23) RE318.2 ; v1(212.34,62.56) v2(215.8,62.56)
  IN2 w0.124: v2(132.7,88.88) 132.93,88.66 137.06,88.66 137.31,88.91 138.35,88.91 139.22,88.04 144.92,88.04 146.31,86.64 146.31,83.95 149.83,80.43 149.83,73.11 151.67,71.27 160.61,71.27 162.09,69.8 172.58,69.8 176.24,66.13 182.92,66.13 184.88,64.17 202.87,64.17 204.88,62.16 215.4,62.16 v2(215.8,62.56) 216.3,62.05 217.76,62.05 218.51,62.8 235.82,62.8 237.13,64.11 241.43,64.11 241.6,64.28 242.35,64.28 243.18,65.11 243.18,68.05 244.49,69.37 245.38,69.37 245.8,69.78 248.07,69.78 v2(248.16,69.87)
  IN3 w0.135: v2(249.52,74.23) 249.52,71.23 v2(248.16,69.87)
  BOTTOM w0.102: UC1.BA5 129.82,91.26 129.58,91.02 129.58,90.52 130.36,89.74 131.85,89.74 v2(132.7,88.88)
  BOTTOM w0.112: v2(215.8,62.56) 214.27,62.56 212.2,60.49 212.2,59.65 212.05,59.5 JKBTP1.5
TP_LAN_JTAG_TCK: length 4.3
  TOP w0.112: v2(242.58,130.64) 243.1,130.12 243.88,130.12 244.48,129.52 UL1.35
  BOTTOM w0.112: RL2.1 242.98,130.25 v2(242.58,130.64) v1(242.58,131.18)
TP_LAN_JTAG_TDI: length 5.6
  TOP w0.112: T88.1 244.14,132.13 245.52,130.76 245.52,129.55 245.68,129.39 UL1.32
TP_LAN_JTAG_TDO: length 2.7
  TOP w0.112: T89.1 243.85,130.81 244.88,129.78 UL1.34
TP_LAN_JTAG_TMS: length 3.2
  TOP w0.112: UL1.33 245.28,129.41 245.2,129.49 245.2,130.25 v2(244.88,130.57)
  BOTTOM w0.112: RL1.1 244.88,130.81 v2(244.88,130.57) v1(245.25,130.2)
TPM_GPIO4: length 1.6
  BOTTOM w0.112: T283.1 162.96,109.72 UZ12.13
TPM_LPM#: length 15.3
  TOP w0.112: v2(158.33,113.41) 158.33,111.66 156.86,110.19 v1(156.86,107.29) 156.86,106.11 155.46,104.71 v2(155.46,104.21)
  BOTTOM w0.112: v2(155.46,104.21) 154.28,104.21 QZ9.1 ; RZ111.1 RZ363.2 158.84,113.92 v2(158.33,113.41) UZ12.3
TPM_PIRQ#: length 48.7
  IN3 w0.135: v2(151.96,104.35) 152.16,104.35 153.31,103.2 159.08,103.2 159.43,102.84 v2(160.5,102.84) ; v2(128.38,95.26) 131.22,95.26 132.04,94.44 144.43,94.44 144.54,94.33 147.95,94.33 v2(148.35,94.73)
  BOTTOM w0.076: UC1.AP8 127.93,95.71 v2(128.38,95.26)
  BOTTOM w0.112: v2(151.96,104.35) 150.68,104.35 149.5,103.17 149.5,102.39 v1(149.43,102.32) 148.95,101.83 148.95,95.52 148.73,95.3 148.73,95.11 v2(148.35,94.73) ; v2(160.5,102.84) 161.07,102.84 161.47,103.23 161.47,105.13 RZ69.2 161.35,106.18 160.82,106.18 160.33,106.67 UZ12.18
TPM_TYPE: length 16.6
  TOP w0.112: RC349.1 138.07,82.83 138.07,85.69 137.64,86.12 v1(136.3,86.12) 135.28,87.13 v2(135.28,87.2)
  BOTTOM w0.076: 130.35,89.19 129.21,90.33 128.65,90.33 128.42,90.56 128.42,91.76 UC1.AY7
  BOTTOM w0.112: v2(135.28,87.2) 135.28,87.76 134.81,88.23 132.03,88.23 131.06,89.19 130.35,89.19
TRST#_XDP: length 14.4
  TOP w0.112: v2(83.47,123.68) 83.47,124.26 v1(83.72,124.5) 84.02,124.8 84.53,124.8 87.47,127.73 87.47,130.54 87.24,130.77 87.24,131.85 v2(87.61,132.22)
  BOTTOM w0.112: JXDP1.54 v2(87.61,132.22) ; v2(83.47,123.68) 83.47,123.95 82.93,124.5 81.96,124.5 81.8,124.34 UC8.12
TYPEC_ID: length 8.5
  TOP w0.107: UE1.F2 250.28,84.25 250.28,83.45 249.96,83.13 249.96,81.23 249.52,80.78 249.52,78.83 CE62.1 RE343.1
  TOP w0.112: v1(249.69,76.69) 249.72,76.72 RE343.1
UART_MISO: length 4.7
  TOP w0.076: 31.47,84.51 31.47,84.08 31.27,83.89 31.27,83.22 UT5.F2
  TOP w0.112: v2(31.42,85.25) 31.47,85.2 31.47,84.51
  BOTTOM w0.112: v1(31.98,85) 31.67,85 v2(31.42,85.25) 31.42,85.82 RT83.1 31.32,86.79 RT82.1
UART_MOSI: length 6
  TOP w0.076: UT5.E2 32.27,83.22 32.27,84 32.58,84.3 32.58,84.51
  TOP w0.112: 32.58,84.51 32.58,84.86 32.64,84.92 v2(32.64,85.15)
  BOTTOM w0.112: RT81.1 32.23,86.79 RT83.2 32.64,85.52 v2(32.64,85.15) 32.64,84.57 32.55,84.48 v1(32.55,83.49)
UG1_ISL88738: length 17.8
  TOP w0.102: v2(48.35,70.37) v1(48.35,66.81)
  IN1 w1.016: 56.89,61.22 55.82,62.3 51.9,62.3 48.03,66.18 48.03,69.48
  vias: v2(47.71,70.37) v2(57.07,59.98) v2(57.35,60.49)
UG2_ISL88738: length 10.3
  TOP w0.508: PQ904.1 v2(60.86,65.42)
  BOTTOM w0.508: v2(60.86,65.42) 60.54,65.42 59.97,64.84 59.97,61.35 60.55,60.77 60.55,57.83 v1(60.42,57.7) 60.37,57.66 60.37,57.62 60.07,57.31 v2(59.84,57.31)
UIM_CLK: length 90.5
  BOTTOM w0.112: JNGFF2.24 238.53,104 238.65,103.88 238.81,103.88 239.48,104.55 252.72,104.55 252.82,104.65 267.1,104.65 268.65,103.09 268.65,99.71 272.92,95.44 272.92,71.24 273.07,71.09 v4(273.07,67.5) 273.07,59.85 275.79,57.14 278.08,57.14 CZ38.1 278.84,57.29 279.16,57.29 279.37,57.5 281.42,57.5 282.47,56.45 284.56,56.45 JSIM1.C3
UIM_DATA: length 105
  IN3 w0.135: v2(297.88,55.18) 288.33,55.18 287.5,56.02 v2(283.63,56.02)
  BOTTOM w0.112: JNGFF2.26 238.51,103.5 238.66,103.64 238.91,103.64 239.58,104.31 252.82,104.31 252.91,104.41 267,104.41 268.42,102.99 268.42,99.61 272.68,95.34 v4(272.68,74.5) 272.68,71.14 272.84,70.99 272.84,59.75 275.69,56.9 277.43,56.9 RZ335.2 CZ39.1 278.91,57.05 279.26,57.05 279.47,57.26 281.32,57.26 282.37,56.21 283.44,56.21 v2(283.63,56.02) ; JSIM1.C7 297.89,55.19 v2(297.88,55.18)
UIM_RESET: length 86.8
  BOTTOM w0.112: JSIM1.C2 284.63,58.71 282.62,58.71 281.51,59.83 278.99,59.83 CZ40.1 277.16,60.29 276.63,60.82 276.63,62.06 273.73,64.96 v3(273.73,71.12) 273.73,71.16 273.35,71.54 273.35,95.6 269.23,99.72 269.23,103.17 267.34,105.06 252.64,105.06 252.54,104.96 239.22,104.96 238.75,104.5 JNGFF2.22
UPD1_ALERT#: length 349.7
  TOP w0.112: RT60.1 37.68,80.66 39.08,82.05 39.08,84.21 v2(39.78,84.91) ; RE91.1 249.79,97.75 v2(249.79,97.29) ; UE1.F10 v2(250.28,91.46)
  IN1 w0.119: v2(249.79,97.29) 249.79,97.12 250.43,96.48 250.43,93.01 250.69,92.75 250.69,91.87 v2(250.28,91.46) UE1.F10 250.68,89.53 250.16,89.01 249.53,89.01 249.08,88.57 249.08,83.89 247.47,82.28 247.47,78.29 v2(246.25,77.07)
  IN2 w0.124: v2(39.78,84.91) 39.97,84.91 41.3,86.24 41.3,97.83 42.45,98.97 42.45,102.52 41.3,103.67 41.3,108.47 40.23,109.54 37.25,109.54 35.71,111.07 32.98,111.07 31.3,112.75 31.3,117.98 37.05,123.73 39.57,123.73 41.45,125.61 46.1,125.61 47.54,127.05 61.65,127.05 62.65,128.05 67.26,128.05 67.56,128.36 75.21,128.36 75.53,128.03 79.48,128.03 83.1,131.65 103.28,131.65 104.16,132.54 106.39,132.54 106.51,132.66 109.18,132.66 109.5,132.34 117.33,132.34 117.89,132.9 123.19,132.9 123.82,133.54 126.14,133.54 127.29,134.69 144.8,134.69 148.61,130.88 153.5,130.88 154.44,131.82 156.25,131.82 157.07,131 158.41,131 159.35,130.06 159.35,123.93 162.5,120.78 162.5,119.99 163.12,119.37 163.12,110.68 168.05,105.76 168.05,90.71 170.12,88.63 170.12,86.04 172.5,83.66 172.5,81.1 181.96,71.65 185.47,71.65 187.16,69.96 206.6,69.96 207.89,68.67 221.02,68.67 221.98,69.63 225.69,69.63 225.99,69.93 226.86,69.93 228.56,71.63 228.56,72.5 229.2,73.14 232.38,73.14 233.7,74.45 234.62,74.45 234.93,74.76 234.93,75.71 235.6,76.39 235.6,76.9 236.79,78.08 243.99,78.08 245,77.07 v2(246.25,77.07)
