# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATT_YELLOW#: length 3.5
  BOTTOM w0.112: JLED1.2 288.47,7.71 288.06,8.11 v2(288.06,8.65) 288.06,9.27 RZ28.2
BBS_BIT6: length 12.7
  TOP w0.112: v2(130.16,96) 130.89,96 131.82,95.07 v1(134.69,95.07) 138.22,95.07 140.11,96.96 RC184.1
  BOTTOM w0.102: UC1.AN5 129.76,96.4 130.17,96 v2(130.16,96)
BC_CLK_ECE1117: length 76.1
  TOP w0.112: UE1.D13 248.98,93.57 248.98,94.64 248.32,95.3 248.32,96.29 v2(248.31,96.29) ; v2(228,62.01) 228,61.8 227.71,61.51 v1(224.83,61.51) 224.82,61.52 218.35,61.52 217.63,60.8 211.89,60.8 211.53,61.17 209.55,61.17 209.17,60.79 v2(209.17,59.84)
  IN3 w0.135: v2(248.31,96.29) 248.03,96.57 243.59,96.57 242.09,95.07 242.09,91.07 240.38,89.37 240.38,80.96 241.01,80.34 241.01,78.33 241.64,77.7 241.64,69.79 240.23,68.38 240.23,66.88 239.83,66.48 237.59,66.48 235.74,64.63 234,64.63 233.06,63.7 230.39,63.7 229.35,62.65 228.28,62.65 228,62.36 v2(228,62.01)
  BOTTOM w0.112: JKBTP1.11 209.05,59.72 v2(209.17,59.84)
BC_DAT_ECE1117: length 79.3
  TOP w0.107: v2(247.81,95.5) 247.81,95.11 248.62,94.3 248.62,93.12 UE1.D12
  TOP w0.112: RE365.1 207.95,58.73 v2(207.95,59.84) 207.95,60.61 v1(208.04,60.7) 209,61.66 211.73,61.66 212.1,61.29 217.43,61.29 218.14,62.01 v2(227.39,62.01)
  IN3 w0.135: v2(247.81,95.5) 247.49,95.82 244.92,95.82 243.61,94.51 243.61,91.87 240.9,89.16 240.9,81.21 241.58,80.53 241.58,79.58 243.24,77.91 243.24,73.66 243.69,73.21 243.69,71.11 240.75,68.16 240.75,66.16 239.92,65.33 237.23,65.33 236.01,64.12 234.21,64.12 233.28,63.18 230.62,63.18 228.83,61.39 227.64,61.39 227.39,61.65 v2(227.39,62.01)
  BOTTOM w0.112: v2(207.95,59.84) 208.05,59.74 JKBTP1.13
BC_INT#_ECE1117: length 58.9
  TOP w0.112: v2(216.81,70.97) v1(216.81,70.45) ; UE1.E2 v2(249.48,84.26)
  IN2 w0.124: v2(216.81,70.97) 216.81,71.64 218.08,72.91 226.03,72.91 226.49,73.37 226.49,76.41 227.25,77.18 229.41,77.18 229.92,76.67 232.38,76.67 232.63,76.42 233.86,76.42 234.36,76.92 234.36,77.51 237.36,80.51 240.8,80.51 241.71,81.42 243.46,81.42 243.76,81.72 243.76,82.97 244.45,83.65 248.88,83.65 v2(249.48,84.26)
  BOTTOM w0.112: v2(216.81,70.97) 216.81,70.57 207.55,61.31 JKBTP1.14
BCM5882_ALERT#: length 55.7
  TOP w0.112: v1(229.96,59.07) 229.96,59.39 v2(230.64,60.07) ; UE1.G10 v2(251.08,91.46)
  IN3 w0.135: v2(230.64,60.07) 230.64,60.86 231.17,61.39 236.46,61.39 237.61,62.55 240.87,62.55 243.76,65.44 243.76,68.38 245.57,70.19 245.57,73.51 244.61,74.48 244.61,79.95 245.11,80.45 245.11,82.69 245.72,83.3 245.72,84.59 246.13,85.01 246.13,89.73 247.46,91.06 250.68,91.06 v2(251.08,91.46)
  BOTTOM w0.112: JUSH1.13 227.45,60.03 228.03,60.6 230.11,60.6 RE532.2 230.86,60.29 v2(230.64,60.07)
BEEP: length 28.7
  TOP w0.107: UE1.L9 v2(255.08,90.66)
  TOP w0.112: v2(249.93,66.46) RA13.2
  IN1 w0.119: v2(255.08,90.66) UE1.L9 253.29,90.26 253.08,90.05 253.08,83.91 252.99,83.81 252.99,79.75 252.59,79.36 252.59,78.96 253.07,78.49 253.07,77.7 v2(252.56,77.19)
  BOTTOM w0.112: v2(249.93,66.46) 249.94,66.47 249.94,67.94 251.84,69.84 251.84,73.06 252.56,73.78 v2(252.56,77.19)
BEEP_R: length 2.9
  TOP w0.112: CA28.1 251.43,64.3 CA62.1 RA45.1 RA13.1
BGATE_ISL88738: length 130.9
  TOP w0.203: PC937.2 59.27,53.67 v1(59.03,53.91) 58.63,54.3 58.25,54.3 57.92,54.64 PU901.32
  TOP w0.254: v2(60.41,53.26) 60.13,52.98 PC937.2 ; PQ906.4 177.54,53.4 v2(178.39,52.55)
  IN1 w0.254: v2(144.93,52.18) 145.57,52.18 148.53,55.15 159.72,55.15 161.54,53.33 177.61,53.33 v2(178.39,52.55)
  IN3 w0.254: v2(60.41,53.26) 62.71,55.56 69.59,55.56 71.61,53.54 72.35,53.54 75.05,50.84 136.02,50.84 138.78,53.6 143.52,53.6 v2(144.93,52.18)
BIA_PWM: length 14.8
  TOP w0.112: DV1.1 72.35,126.12 71.54,126.12 RV1.1 70.88,125.59 69.17,125.59 67.92,124.34 64.26,124.34 62.52,126.08 v1(62.52,128.2) LV1.2
BIA_PWM_EC: length 242.8
  TOP w0.107: UE1.N1 v2(256.68,83.46)
  TOP w0.112: DV1.2 75.26,125.22 75.95,124.53 v1(76.41,124.53) 77.9,124.53 78.36,125 v2(78.36,125.47)
  IN2 w0.124: v2(78.36,125.47) 78.36,125.6 78.63,125.87 80.2,125.87 83.68,129.35 104.08,129.35 104.55,128.88 108.32,128.88 108.83,129.38 118,129.38 118.2,129.58 122.63,129.58 123.05,129.15 126.69,129.15 127.26,129.73 130.56,129.73 131.82,128.46 138.84,128.46 139.25,128.87 140.27,128.87 140.82,128.32 144.45,128.32 146,126.76 147.02,126.76 147.99,125.79 154.22,125.79 159.13,120.88 159.13,118.96 161.31,116.78 161.31,109.85 165.95,105.21 165.95,90.22 168.31,87.85 168.31,85.29 170.65,82.95 170.65,79.9 180.72,69.84 184.72,69.84 186.45,68.11 205.69,68.11 207.02,66.77 225.73,66.77 227.08,68.12 231.43,68.12 231.85,68.54 233.14,68.54 234.55,69.95 235.97,69.95 236.42,70.41 239.29,70.41 240.07,71.19 240.07,72.63 241.52,74.08 245.03,74.08 245.79,73.32 248.83,73.32 249.06,73.54 250.16,73.54 251.63,75.01 254.54,75.01 v2(255.85,75.01)
  BOTTOM w0.112: v2(256.68,83.46) 256.4,83.17 256.4,80.67 256.03,80.3 256.03,77 255.83,76.8 255.83,75.03 v2(255.85,75.01)
BL_PWR_SRC_ON: length 5.4
  TOP w0.254: QV1.3 44.35,124.5 v2(43.95,124.1) 43.46,124.1 RV4.1 CV14.1 RV5.1 CV13.1
  BOTTOM w0.112: v2(43.95,124.1) v1(43.95,123.44)
BOARD_ID: length 10.8
  TOP w0.107: CE40.1 253.08,97.25 UE1.J13
  TOP w0.112: RE79.2 251.03,102.44 251.56,102.44 252.12,101.88 252.12,99.13 v1(252.75,98.51) 252.73,98.49 CE40.1
BOOT1_ISL88738:
  vias: v1(56.53,60.16)
BOOT2_ISL88738: length 1.4
  TOP w0.112: v1(61.21,55.66) 60.79,56.08 PC934.2
BREATH_LED#: length 36.1
  TOP w0.107: UE1.C11 v2(247.88,92.26)
  TOP w0.112: QZ7.4 266.17,83.53 v1(265.75,83.11) v2(265.31,82.68)
  IN2 w0.124: v2(265.31,82.68) 264.55,83.44 264.55,86.12 264.21,86.46 264.21,87.55 262.62,89.13 262.62,91.86 261.48,93.01 260.57,93.01 258.9,94.67 258.9,98.64 258.67,98.87 257.99,98.87 257.73,98.61 257.2,98.61 256.61,98.03 256.61,96.56 256.22,96.16 251.92,96.16 248.02,92.26 v2(247.88,92.26)
BREATH_LED#_Q: length 2.1
  TOP w0.112: v1(269.71,82.59) RZ32.1 268.59,83.5 QZ7.3
BREATH_WHITE_LED_SNIFF#: length 114.1
  TOP w0.112: LED3.1 v2(292.97,127.59) ; RZ32.2 v2(269.71,85.04)
  IN3 w0.135: v2(269.71,85.04) 271.04,85.04 272.21,86.21 272.21,95.92 269.09,99.05 269.09,102.4 266.57,104.91 258.95,104.91 257.28,106.59 257.28,111.39 252.37,116.29 252.37,122.16 259.02,128.81 285.18,128.81 285.84,128.15 285.84,122.44 286.28,121.99 286.28,120.34 286.73,119.9 290.6,119.9 292.97,122.27 v2(292.97,127.59)
  BOTTOM w0.112: v2(269.71,85.04) 269.71,82.48 v1(270.2,81.99)
BST_3V: length 0.8
  BOTTOM w0.112: v1(155.19,72.38) 155.29,72.48 155.29,73.11
BST_5V:
  vias: v1(186.78,52.91)
BST_+1VALWP:
  vias: v1(154.05,85.1) v2(153.48,85.14) v2(153.48,84.57)
BST_+1VALWP_C: length 1.3
  TOP w0.112: PR304.1 v1(156.42,85.14)
BT_RADIO_DIS#: length 22.6
  TOP w0.107: RE11.1 v2(247.04,81.54) 247.04,82.73 247.88,83.57 247.88,84.26 UE1.C2
  TOP w0.112: DZ2.1 243.84,67.54 243.84,68.41 v1(244.31,68.88) 244.37,68.95 246,68.95 v2(246.12,68.82)
  IN3 w0.135: v2(247.04,81.54) 247.04,81.11 247.53,80.63 247.53,79.24 247.06,78.78 246.79,78.78 245.55,77.54 245.55,75.89 246.66,74.78 246.66,70.27 246.12,69.74 v2(246.12,68.82)
BT_RADIO_DIS#_R: length 2.5
  TOP w0.112: DZ2.2 v2(242.04,67.32) 241.6,67.75 v1(241.6,67.91)
  BOTTOM w0.102: JNGFF1.54 241.96,67.4 v2(242.04,67.32)
CAM_MIC_CBL_DET#: length 129.9
  TOP w0.112: RC413.1 133.56,103.77 128.61,103.77 127.91,103.07 127.19,103.07 v2(126.74,102.63)
  IN2 w0.124: v2(71.72,125.55) 72.73,125.55 74.14,124.14 74.14,124.14 74.4,123.89 81.66,123.89 82.95,125.18 85.72,125.18 85.97,124.94 91.05,124.94 91.59,125.49 93.34,125.49 93.73,125.1 97,125.1 97.97,126.07 104.01,126.07 104.47,126.53 111.12,126.53 111.58,126.98 119.93,126.98 120.32,127.37 121.74,127.37 122.77,126.34 133.32,126.34 134.76,124.9 134.76,123.28 134.39,122.91 134.39,121.14 133.96,120.71 133.96,119.59 135.23,118.32 135.23,111.44 134.94,111.15 134.94,110.61 135.38,110.17 135.38,105.8 135.86,105.32 136.83,105.32 137.13,105.01 137.13,103.76 136.48,103.11 133.09,103.11 132.21,102.22 127.15,102.22 v2(126.74,102.63)
  BOTTOM w0.102: UC1.AB11 v2(126.74,102.63)
  BOTTOM w0.107: JEDP1.14 57.75,132.11 59.31,130.55
  BOTTOM w0.112: 59.31,130.55 59.31,128.08 61.19,126.2 62.69,126.2 64.73,124.16 v1(65.35,124.16) 71.26,124.16 71.72,124.61 v2(71.72,125.55)
CFG0: length 37.7
  TOP w0.112: v2(90.5,125.53) v1(89.42,124.46) 89.1,124.14 89.1,120.09 87.91,118.9 v2(87.91,118.25)
  IN2 w0.124: v2(94.55,125.53) 94.14,125.94 90.91,125.94 v2(90.5,125.53)
  BOTTOM w0.076: 90.96,115.52 91.6,115.52 92.18,114.95 92.57,114.95 92.9,114.62 94.07,114.62 94.39,114.3 94.39,113.93 94.63,113.69 94.63,113.54 94.63,113.54 94.63,113.18 94.63,113.17 94.6,113.08 94.6,112.94 94.61,112.85 94.63,112.77 94.63,112.71 94.63,112.6 94.63,112.59 94.63,112.55 94.61,112.49 94.58,112.4 94.53,112.22 94.49,111.96 94.42,111.69 UC1.E68
  BOTTOM w0.112: JXDP1.9 101.11,126.58 100.06,125.53 v2(94.55,125.53) ; RC126.1 90.26,125.78 v2(90.5,125.53) ; 90.96,115.52 90.64,115.52 v2(87.91,118.25) 87.72,118.44 87.72,120.17 RC113.1
CFG1: length 31
  TOP w0.112: v2(100.51,128.79) 100.25,128.53 100.25,124.88 98.82,123.44 96.91,123.44 95.99,122.51 v1(95.99,121.91) 95.99,121.04 95.48,120.53 95.48,116.28 93.69,114.49 93.47,114.49 v2(93.06,114.08)
  BOTTOM w0.076: v2(93.06,114.08) 93.2,114.08 93.84,113.44 93.84,113.02 UC1.B67
  BOTTOM w0.112: v2(93.06,114.08) 92.82,114.08 92.51,114.39 90.44,114.39 86.51,118.31 86.51,118.68 RC112.1 ; JXDP1.11 v2(100.51,128.79)
CFG2: length 25.9
  TOP w0.112: v2(91.85,115.89) 93.39,117.44 93.39,118.53 94.11,119.25 94.11,121.61 96.69,124.19 98.34,124.19 99.31,125.16 v1(99.31,128.13) v2(99.31,128.79)
  BOTTOM w0.076: UC1.D65 95.33,111.69 95.26,111.96 95.26,112.07 95.12,112.55 95.12,112.8 95.15,112.89 95.15,113.08 95.12,113.18 95.12,113.54 95.23,113.65 95.23,114.18 94.51,114.9 94.51,115.68 93.88,116.32 92.91,116.32 92.48,115.89 v2(91.85,115.89)
  BOTTOM w0.112: JXDP1.15 v2(99.31,128.79)
CFG3: length 31.3
  TOP w0.112: v2(98.71,128.79) v1(98.71,125.19) 97.96,124.44 96.64,124.44 93.9,121.7 93.9,119.36 93.17,118.63 93.17,117.8 91.34,115.97 91.34,115.1 v2(91.46,114.97)
  BOTTOM w0.076: v2(91.46,114.97) 91.69,114.74 92.54,114.74 92.83,114.45 94,114.45 94.21,114.24 94.21,113.88 94.47,113.62 94.47,113.21 94.41,113.09 94.41,112.94 94.47,112.75 94.47,112.58 94.38,112.32 UC1.D67
  BOTTOM w0.112: JXDP1.17 v2(98.71,128.79) 99.02,128.48 RC121.2 ; v2(91.46,114.97) 90.44,114.97 87.21,118.2 RC110.1
CFG4: length 34
  TOP w0.112: v2(88.62,112.17) 88.99,112.17 90.14,113.32 90.14,117.31 90.63,117.79 90.63,118.68 92.82,120.87 92.82,122.19 95.32,124.7 95.32,126.99 95.71,127.37 v1(95.71,127.6) v2(95.71,128.79)
  BOTTOM w0.076: 91.34,111.49 91.63,111.21 91.96,111.21 92.16,111.01 UC1.E70
  BOTTOM w0.112: JXDP1.27 v2(95.71,128.79) ; 91.34,111.49 90.67,112.17 v2(88.62,112.17) 88.62,112.17 88.62,112.51 88.11,113.02 87.83,113.02 87.58,113.27 87.58,115.91 85.24,118.25 84.67,118.25 84.48,118.44 RC109.1
CFG5: length 23.2
  TOP w0.112: v2(95.11,128.79) 95.11,127.18 95.02,127.09 95.02,124.75 92.43,122.16 v1(92.43,121.73) 92.43,120.87 90.4,118.83 90.4,117.92 89.91,117.44 89.91,113.68 v2(89.69,113.45)
  BOTTOM w0.076: UC1.C68 93.28,111.62 92.54,112.36 92.23,112.36 92.05,112.53 91.51,112.53
  BOTTOM w0.112: v2(89.69,113.45) 89.71,113.47 90.58,113.47 91.51,112.53 ; JXDP1.29 v2(95.11,128.79)
CFG6: length 23.6
  TOP w0.112: v2(93.91,128.79) 93.91,126.23 93.57,125.89 93.57,124.29 90.88,121.6 v1(90.88,120.89) 90.88,120.51 89.03,118.65 89.03,116.14 88.62,115.73 v2(88.62,113.45)
  BOTTOM w0.076: 91.59,111.84 91.98,111.84 92.29,111.54 UC1.D68
  BOTTOM w0.112: v2(88.62,113.45) 89.15,112.91 90.52,112.91 91.59,111.84 ; JXDP1.33 v2(93.91,128.79)
CFG7: length 25.8
  TOP w0.112: v2(93.31,128.79) 93.31,127.7 v1(93.45,127.57) 93.45,126.2 90.48,123.23 90.48,120.47 88.8,118.78 88.8,116.22 88.24,115.66 88.24,113.68 v2(88.01,113.45)
  BOTTOM w0.076: UC1.C67 92.98,112.3 92.73,112.54 92.73,112.95 92.57,113.11 92.57,113.57 92.29,113.85
  BOTTOM w0.112: 92.29,113.85 89.89,113.85 89.69,114.06 88.62,114.06 v2(88.01,113.45) ; JXDP1.35 v2(93.31,128.79)
CFG8: length 30.1
  TOP w0.112: v2(90.27,111.03) 90.7,111.47 91.24,111.47 92.51,112.74 92.51,115.89 94.31,117.7 94.31,117.87 94.58,118.14 94.58,120.12 95.14,120.68 95.14,122 96.84,123.7 98.63,123.7 100.02,125.09 100.02,129.54 100.81,130.33 v1(100.81,131.58) v2(100.81,132.22)
  BOTTOM w0.076: v2(90.27,111.03) 90.27,110.88 90.7,110.45 92.17,110.45 UC1.F71
  BOTTOM w0.112: JXDP1.10 v2(100.81,132.22)
CFG9: length 36
  TOP w0.112: v2(87.88,110.75) 88.06,110.58 89.64,110.58 89.86,110.81 89.86,111.21 90.42,111.77 91.15,111.77 92.28,112.9 92.28,115.96 94.05,117.74 94.05,117.94 94.37,118.26 94.37,120.26 94.91,120.81 94.91,122.08 96.79,123.95 98.52,123.95 99.78,125.21 v1(99.78,129.89) 100.21,130.32 v2(100.21,132.22)
  BOTTOM w0.076: UC1.G69 92.98,109.56 92.73,109.56 92.51,109.48 92.38,109.48 92.15,109.55 92.01,109.55 91.89,109.49 91.63,109.49 91.5,109.62 89.9,109.62
  BOTTOM w0.102: 89.9,109.62 89.02,109.62 v2(87.88,110.75)
  BOTTOM w0.112: JXDP1.12 v2(100.21,132.22)
CFG10: length 30.9
  TOP w0.112: v2(99.01,132.22) 99.01,129.86 98.3,129.14 98.3,125.39 97.61,124.7 96.57,124.7 93.69,121.82 93.69,120.38 91.55,118.25 91.55,117.38 91.06,116.89 91.06,112.84 89.46,111.24 v2(89.46,111.03)
  BOTTOM w0.076: UC1.F70 92.56,110.65 91.96,110.65 91.94,110.63 90.95,110.63 90.7,110.88 90.7,111.19 90.42,111.47 89.89,111.47 v2(89.46,111.03)
  BOTTOM w0.112: JXDP1.16 v2(99.01,132.22)
CFG11: length 31.9
  TOP w0.112: v2(88.85,111.03) 90.83,113.02 90.83,116.98 91.31,117.46 91.31,118.35 93.46,120.5 93.46,121.89 96.5,124.94 97.42,124.94 98.04,125.56 98.04,129.3 98.41,129.67 v1(98.41,131.48) v2(98.41,132.22)
  BOTTOM w0.076: UC1.G68 93.2,109.93 93.13,109.95 92.66,109.95 92.59,110.03 92.33,110.03 91.77,110.27 89.61,110.27 v2(88.85,111.03)
  BOTTOM w0.112: JXDP1.18 v2(98.41,132.22)
CFG12: length 33.5
  TOP w0.112: v2(90.47,108.98) 89.71,109.74 87.6,109.74 86.94,110.4 86.94,111.16 87.48,111.69 87.91,111.69 88.16,111.95 88.16,112.26 88.58,112.68 88.96,112.68 89.28,112.99 89.28,115.76 89.48,115.96 89.48,118.3 92.1,120.91 92.1,122.16 94.03,124.09 94.03,125.64 94.64,126.25 94.64,129.07 v1(95.41,129.84) v2(95.41,132.22)
  BOTTOM w0.076: UC1.H70 92.53,108.86 92.3,108.86 92.17,108.81 92.06,108.81 91.92,108.86 91.52,108.86 91.25,108.6 90.85,108.6 v2(90.47,108.98)
  BOTTOM w0.112: JXDP1.28 v2(95.41,132.22)
CFG13: length 29.6
  TOP w0.112: v2(94.81,132.22) v1(94.81,131.48) 94.81,129.62 94.39,129.2 94.39,126.38 93.8,125.79 93.8,124.19 91.26,121.65 91.26,120.56 89.25,118.55 89.25,116.06 89.05,115.86 89.05,113.07 88.87,112.89 88.49,112.89 v2(87.7,112.1)
  BOTTOM w0.076: 87.94,111.74 88.24,111.44 88.24,110.81 89.22,109.82 91.72,109.82 UC1.G71
  BOTTOM w0.112: 87.94,111.74 87.7,111.97 v2(87.7,112.1) ; JXDP1.30 v2(94.81,132.22)
CFG14: length 33.3
  TOP w0.112: v2(93.61,132.22) v1(93.61,129.64) 92.86,128.89 92.86,128.28 92.58,128 92.58,125.74 90.27,123.42 90.27,120.58 88.57,118.88 88.57,116.32 87.6,115.35 87.6,112.84 86.69,111.92 86.69,110.3 87.5,109.48 89.36,109.48 v2(89.86,108.98)
  BOTTOM w0.076: UC1.H69 93.14,109.37 92.68,109.37 92.52,109.31 92.38,109.31 92.16,109.37 92.04,109.37 91.93,109.33 91.52,109.33 91.45,109.39 90.28,109.39 v2(89.86,108.98)
  BOTTOM w0.112: JXDP1.34 v2(93.61,132.22)
CFG15: length 29.8
  TOP w0.112: v2(87.15,113.45) 87.15,115.25 88.34,116.44 88.34,118.98 90.05,120.7 90.05,123.59 92.3,125.84 92.3,128.05 92.61,128.36 92.61,129.4 93.01,129.8 v1(93.01,131.28) v2(93.01,132.22)
  BOTTOM w0.076: 88.16,111.9 88.44,111.62 88.44,110.86 89.27,110.02 91.46,110.02 91.48,110.05 91.84,110.05 92.14,109.91 92.14,109.9 92.15,109.9 92.29,109.76 UC1.G70
  BOTTOM w0.112: 88.16,111.9 88.16,112.48 87.91,112.74 87.55,112.74 87.15,113.14 v2(87.15,113.45) ; JXDP1.36 v2(93.01,132.22)
CFG16: length 29.2
  TOP w0.112: v2(102.01,132.22) v1(102.01,129.96) 102.01,129.81 101.22,129.02 101.22,125.48 98.92,123.19 97.27,123.19 96.34,122.26 96.34,121.09 95.7,120.44 95.7,116.19 94.19,114.68 94.19,111.92 94.84,111.26 94.84,110.63 v2(95.24,110.23)
  BOTTOM w0.102: UC1.E63 96.73,110.65 96.4,110.33 95.34,110.33 v2(95.24,110.23)
  BOTTOM w0.112: JXDP1.6 v2(102.01,132.22)
CFG17: length 30.2
  TOP w0.112: v2(102.61,132.22) v1(102.61,131.63) 102.61,130.03 101.45,128.87 101.45,125.35 99.03,122.93 97.32,122.93 96.57,122.18 96.57,120.99 95.91,120.33 95.91,116.1 94.41,114.6 94.41,113.27 95.66,112.02 95.66,110.06 v2(95.24,109.64)
  BOTTOM w0.102: v2(95.24,109.64) 95.29,109.69 96.43,109.69 96.74,110 UC1.F63
  BOTTOM w0.112: JXDP1.4 v2(102.61,132.22)
CFG18: length 35.2
  TOP w0.112: v2(94.14,110.81) 93.83,110.5 91.78,110.5 91.3,110.02 87.68,110.02 87.2,110.5 87.2,111.06 87.6,111.47 87.98,111.47 88.19,111.67 88.8,111.67 90.37,113.24 90.37,117.21 90.85,117.69 90.85,118.55 93.03,120.73 93.03,122.08 95.58,124.62 95.58,126.81 96.61,127.84 v1(96.61,131.68) v2(96.61,132.22)
  BOTTOM w0.102: UC1.E66 v2(94.14,110.81)
  BOTTOM w0.112: JXDP1.24 v2(96.61,132.22)
CFG19: length 36.6
  TOP w0.112: v2(94.14,110.21) 94.54,110.6 94.54,111.05 94.19,111.39 92.23,111.39 91.11,110.27 87.76,110.27 87.45,110.58 87.45,110.93 87.73,111.21 88.06,111.21 88.29,111.44 88.92,111.44 90.6,113.12 90.6,117.1 91.08,117.59 91.08,118.48 93.24,120.64 93.24,121.98 95.86,124.6 95.86,126.71 97.21,128.06 v1(97.21,128.64) v2(97.21,132.22)
  BOTTOM w0.102: UC1.F66 v2(94.14,110.21)
  BOTTOM w0.112: JXDP1.22 v2(97.21,132.22)
CFG_RCOMP: length 2.2
  TOP w0.127: v2(98.18,110.89) 98.18,111.07 v1(97.92,111.34)
  TOP w0.381: RC114.1 98.18,110.59 v2(98.18,110.89)
  BOTTOM w0.254: v2(98.18,110.89) 98.26,110.85 98.26,110.8 98.66,110.61 UC1.E60
CLK_ITPXDP_N: length 16
  TOP w0.104: RC297.1 101.32,120.34 101.32,119.39 101.09,119.16 v4(101.09,118.22) 101.09,116.01 102.15,114.96 104.64,114.96 105.64,113.96 106.11,113.96 106.79,113.27 106.8,113.27 107.13,112.93 107.13,112.93 108,112.06 108,110.58 107.82,110.4 107.54,110.4 v2(107.38,110.25)
  BOTTOM w0.089: UC1.F43 107.69,109.94 v2(107.38,110.25)
CLK_ITPXDP_N_R: length 26.2
  TOP w0.104: RC297.2 101.5,121.94 101.72,122.17 101.72,123.45 v4(102.29,124.01) 103.27,125 103.27,127.61 103.98,128.32 103.98,132.42 103.55,132.85 91.63,132.85 91.4,132.63 91.4,132.41 v2(91.21,132.22)
  BOTTOM w0.104: JXDP1.42 v2(91.21,132.22)
CLK_ITPXDP_P: length 15.9
  TOP w0.104: v2(107.38,110.83) 107.61,110.6 107.74,110.6 107.8,110.66 107.8,111.98 v4(106.82,112.96) 106.02,113.75 105.55,113.75 104.55,114.76 102.06,114.76 100.89,115.93 100.89,117.91 100.86,117.94 100.86,118.51 100.89,118.54 100.89,119.25 101.12,119.47 101.12,120.12 100.71,120.52 RC298.1
  BOTTOM w0.089: UC1.E43 107.62,110.59 v2(107.38,110.83)
CLK_ITPXDP_P_R: length 26
  TOP w0.104: RC298.2 100.76,121.44 101.04,121.72 101.04,121.77 101.52,122.25 101.52,123.53 101.92,123.93 101.92,123.97 102.33,124.38 102.37,124.38 103.07,125.08 103.07,127.7 103.78,128.41 103.78,132.34 103.47,132.65 91.71,132.65 91.6,132.55 91.6,132.33 91.72,132.22 v2(91.81,132.22)
  BOTTOM w0.104: JXDP1.40 v2(91.81,132.22)
CLK_PCIE_N0: length 231
  TOP w0.104: v2(269.03,64.13) 269.24,64.35 272.73,64.35 272.81,64.27 UR1.6
  IN1 w0.119: v2(269.03,64.13) 269.97,64.13 271.53,65.69 271.53,75.89 270.48,76.93 262.17,76.93 260.91,75.67 255.62,75.67 253,73.05 250.59,73.05 249.22,71.69 245.15,71.69 243.71,70.24 234.48,70.24 232.48,72.25 231.11,72.25 229.85,70.99 v2(229.85,69.8) ; v2(107.39,114.6) 107.54,114.75 107.88,114.75 110.22,117.09 113.04,117.09 113.36,117.41 117.14,117.41 117.42,117.69 119.53,117.69 122.23,120.39 132.8,120.39 133.56,121.15 138.76,121.15 139.18,121.58 154.92,121.58 161.31,115.19 161.31,112.4 168.03,105.68 168.03,99.75 arc(170.39,87.9) 177.1,77.86 177.83,77.13 arc(186.24,71.51) 196.16,69.54 225.9,69.54 227.07,70.72 227.07,71.99 v2(227.09,72)
  BOTTOM w0.076: UC1.D42 107.65,111.8 107.65,112.07 107.61,112.2 107.55,112.41 107.51,112.55 107.51,112.8 107.54,112.89 107.54,113.08 107.51,113.18 107.51,113.56 107.66,113.72 107.66,113.86 107.85,114.04 107.85,114.67 107.72,114.8 107.59,114.8 v2(107.39,114.6)
  BOTTOM w0.104: v2(227.09,72) 227.09,71 228.99,69.1 230.06,69.1 230.23,69.27 230.23,69.41 v2(229.85,69.8)
CLK_PCIE_N1: length 169.6
  IN1 w0.119: v2(107.47,117.18) 107.74,116.9 107.92,116.9 109.14,118.12 112.7,118.12 112.97,118.39 116.88,118.39 117.08,118.59 119.21,118.59 121.88,121.27 132.44,121.27 133.19,122.02 135.42,122.02 136.05,122.65 138.97,122.65 139.17,122.45 155.27,122.45 162.23,115.5 162.23,112.77 168.91,106.09 168.91,99.75 arc(171.2,88.24) 177.72,78.48 178.45,77.75 arc(186.59,72.31) 196.19,70.4 212.96,70.4 214.17,71.61 220.83,71.61 222.04,70.4 225.43,70.4 225.88,70.85 225.88,71.27 v2(225.69,71.46)
  BOTTOM w0.076: v2(107.47,117.18) 107.67,116.98 108.18,116.98 108.43,116.72 108.43,113.9 108.21,113.68 108.21,112.93 UC1.B42
  BOTTOM w0.104: v2(225.69,71.46) 225.87,71.28 225.87,70.88 228.48,68.26 230.89,68.26 231.43,68.8 232.42,68.8 232.57,68.65 JNGFF1.49
CLK_PCIE_N2: length 174.7
  IN1 w0.119: v2(223.46,71.44) 223.64,71.26 223.64,71.14 223.54,71.04 222.46,71.04 221.25,72.26 213.7,72.26 212.49,71.05 196.21,71.05 arc(186.85,72.92) 178.92,78.22 178.19,78.95 arc(171.81,88.49) 169.57,99.75 169.57,106.33 162.91,112.99 162.91,115.92 155.72,123.11 139.48,123.11 139.26,123.34 135.61,123.34 135.01,122.73 132.96,122.73 132.19,121.96 121.66,121.96 118.98,119.28 116.85,119.28 116.62,119.05 112.59,119.05 112.3,118.76 108.17,118.76 v2(107.97,118.96)
  BOTTOM w0.076: v2(107.97,118.96) 108.17,118.77 108.42,118.77 108.77,118.42 108.77,113.76 108.57,113.56 108.57,112.69 108.8,112.46 108.8,112.15 108.5,111.85 UC1.D41
  BOTTOM w0.104: JNGFF1.73 232.48,62.65 232.33,62.8 228.67,62.8 226.98,64.49 226.98,66.12 223.66,69.44 223.66,71.24 v2(223.46,71.44)
CLK_PCIE_N3: length 154.7
  IN1 w0.119: v2(110.56,113.95) 110.37,114.14 109.84,114.14 108.7,113 108.7,109.14 107.93,108.37 96.87,108.37 95.83,109.41 95.83,110.97 95.58,111.22 93.84,111.22 93.67,111.06 93.67,110.55 91.15,108.02 88.71,108.02 87.77,107.08 80.55,107.08 79.48,106 79.48,105.47 73.25,99.24 73.25,93.07 68.47,88.29 62.04,88.29 61.42,88.91 56.79,88.91 56.2,89.51 48.97,89.51 47.56,90.91 46.53,90.91 45.48,89.86 43.31,89.86 v2(43.13,89.68)
  IN3 w0.135: v2(15.99,45.06) 15.82,45.23 15.82,46.57 16.38,47.13 21.74,47.13 23.77,49.16 23.77,53.48 29.42,59.13 29.42,65.01 37.29,72.87 37.29,79.92 39.33,81.97 39.33,83.3 41.9,85.86 41.9,89.19 42.56,89.85 42.96,89.85 v2(43.13,89.68)
  BOTTOM w0.076: UC1.D40 109.28,111.69 109.36,111.96 109.36,112.07 109.49,112.53 109.5,112.55 109.5,112.8 109.46,112.89 109.46,112.92 109.45,112.97 109.45,112.99 109.47,113.03 109.48,113.08 109.5,113.16 109.5,114.08 109.58,114.16 110.36,114.16 v2(110.56,113.95)
  BOTTOM w0.104: JNGFF3.53 15.95,44.47 15.8,44.62 15.8,44.87 v2(15.99,45.06)
CLK_PCIE_N4: length 225.7
  TOP w0.104: UL1.45 242.83,124.93 242.67,125.1 242.24,125.1 241.84,124.7 238.09,124.7 237.92,124.53 237.92,124.24 v2(238.11,124.05)
  IN1 w0.119: v2(110.55,116.42) 110.82,116.15 112.84,116.15 113.66,116.98 117.39,116.98 117.66,117.25 120.74,117.25 121.13,117.64 121.13,118.58 122.5,119.95 132.28,119.95 133.18,119.04 137.28,119.04 139.38,121.14 154.52,121.14 160.87,114.79 160.87,112.24 167.6,105.51 167.6,99.75 arc(169.99,87.74) 176.8,77.56 177.52,76.83 arc(186.07,71.12) 196.14,69.12 226.53,69.12 227.64,70.23 227.64,72.17 226.2,73.62 226.2,77.62 227.2,78.63 227.2,79.78 230.74,83.32 230.74,92.99 232.85,95.1 232.85,102.12 233.29,102.56 233.29,114.01 233.41,114.13 233.41,122.32 235.96,124.88 237.59,124.88 237.91,124.56 237.91,124.26 v2(238.11,124.05)
  BOTTOM w0.076: UC1.B40 109.07,112.91 108.81,113.16 108.81,113.56 108.94,113.69 108.94,115.35 109.82,116.24 110.36,116.24 v2(110.55,116.42)
CLK_PCIE_N5: length 109.5
  TOP w0.094: v2(30.99,105.19) UT1.T19
  IN1 w0.076: v2(110.09,110.81) 109.96,110.81 109.55,110.4 109.55,109.39 108.64,108.47 108.64,107.7 108.53,107.59 108.5,107.59 108.48,107.58
  IN1 w0.119: v2(30.99,105.19) 30.99,105.25 31.74,106.01 33.25,106.01 33.76,105.5 33.76,104.07 38.83,99 38.83,96.97 39.21,96.59 39.21,92.94 38.97,92.69 38.97,91.96 41.74,89.19 45.64,89.19 46.38,89.93 47.9,89.93 48.75,89.08 55.87,89.08 56.55,88.39 61.2,88.39 61.78,87.82 70.08,87.82 73.69,91.44 73.69,99.08 80.48,105.87 89.93,105.87 92.5,108.44 96.19,108.44 96.78,107.86 97.59,107.86 97.97,107.48 108.38,107.48 108.48,107.58
  BOTTOM w0.076: UC1.E40 v2(110.09,110.81)
CLK_PCIE_P0: length 230.8
  TOP w0.104: v2(269.03,64.72) 269.19,64.55 272.72,64.55 272.84,64.67 UR1.5
  IN1 w0.119: v2(107.39,115.29) 107.39,115.11 107.53,114.97 107.79,114.97 110.13,117.31 112.95,117.31 113.27,117.63 117.05,117.63 117.33,117.91 119.44,117.91 122.14,120.61 132.71,120.61 133.46,121.37 138.66,121.37 139.09,121.79 155.01,121.79 161.53,115.28 161.53,112.49 168.25,105.77 168.25,99.75 arc(170.59,87.99) 177.26,78.02 177.99,77.29 arc(186.32,71.72) 196.16,69.76 225.8,69.76 226.86,70.81 226.86,71.62 226.51,71.96 v2(226.51,72) ; v2(230.43,69.8) 230.43,69.84 230.07,70.21 230.07,70.9 231.2,72.03 232.39,72.03 234.39,70.03 243.8,70.03 245.24,71.47 249.31,71.47 250.68,72.83 253.09,72.83 255.71,75.45 261,75.45 262.26,76.72 270.39,76.72 271.31,75.8 271.31,65.78 269.88,64.35 269.43,64.35 269.06,64.72 v2(269.03,64.72)
  BOTTOM w0.076: v2(107.39,115.29) 107.29,115.19 107.29,115.08 107.4,114.97 107.8,114.97 108.02,114.75 108.02,113.97 107.84,113.78 107.84,113.66 107.67,113.49 107.67,113.21 107.73,113.09 107.73,112.94 107.67,112.75 107.67,112.58 107.76,112.32 107.78,112.31 107.78,112.25 107.82,112.1 107.82,112.09 107.9,112.01 UC1.C42
  BOTTOM w0.104: v2(226.51,72) 226.89,71.62 226.89,70.92 228.91,68.9 230.14,68.9 230.43,69.19 v2(230.43,69.8)
CLK_PCIE_P1: length 169.4
  IN1 w0.119: v2(226.28,71.46) 226.1,71.28 226.1,70.76 225.52,70.18 221.95,70.18 220.74,71.4 214.26,71.4 213.05,70.18 196.19,70.18 arc(186.5,72.11) 178.29,77.6 177.57,78.32 arc(171,88.16) 168.69,99.75 168.69,105.99 162.01,112.68 162.01,115.41 155.18,122.24 139.08,122.24 138.88,122.43 136.14,122.43 135.51,121.8 133.28,121.8 132.53,121.05 121.97,121.05 119.3,118.37 117.17,118.37 116.97,118.17 113.06,118.17 112.79,117.9 109.23,117.9 108.02,116.68 107.74,116.68 v2(107.47,116.41)
  BOTTOM w0.076: v2(107.47,116.41) 107.29,116.41 107.15,116.55 107.15,116.73 107.23,116.81 108.11,116.81 108.26,116.65 108.26,113.97 108.04,113.75 108.04,113.41 UC1.A42
  BOTTOM w0.104: v2(226.28,71.46) 226.07,71.25 226.07,70.96 228.57,68.46 230.81,68.46 231.34,69 232.42,69 232.57,69.15 JNGFF1.47
CLK_PCIE_P2: length 174.7
  IN1 w0.119: v2(224.04,71.44) 223.86,71.27 223.86,71.05 223.63,70.83 222.37,70.83 221.16,72.04 213.79,72.04 212.59,70.84 196.21,70.84 arc(186.77,72.71) 178.76,78.06 178.03,78.79 arc(171.61,88.41) 169.35,99.75 169.35,106.24 162.7,112.9 162.7,115.83 155.63,122.9 139.39,122.9 139.17,123.12 135.7,123.12 135.1,122.52 133.06,122.52 132.28,121.74 121.75,121.74 119.07,119.06 116.94,119.06 116.71,118.83 112.68,118.83 112.39,118.55 108.19,118.55 v2(107.97,118.33)
  BOTTOM w0.076: UC1.C41 108.5,112.11 108.42,112.03 108.35,112.03 108.09,112.29 108.09,112.39 108.39,112.69 108.39,113.63 108.6,113.83 108.6,118.34 108.35,118.59 108.09,118.59 107.97,118.47 v2(107.97,118.33)
  BOTTOM w0.104: JNGFF1.71 232.48,63.15 232.33,63 228.75,63 227.18,64.58 227.18,66.2 223.86,69.52 223.86,71.26 v2(224.04,71.44)
CLK_PCIE_P3: length 154.7
  IN1 w0.119: v2(43.13,90.26) 43.31,90.08 45.39,90.08 46.44,91.13 47.65,91.13 49.06,89.72 56.29,89.72 56.88,89.13 61.51,89.13 62.13,88.5 68.38,88.5 73.03,93.16 73.03,99.34 79.26,105.56 79.26,106.1 80.46,107.3 87.68,107.3 88.62,108.24 91.06,108.24 93.46,110.64 93.46,111.15 93.75,111.44 95.67,111.44 96.05,111.06 96.05,109.5 96.97,108.59 107.84,108.59 108.48,109.23 108.48,113.09 109.75,114.36 110.39,114.36 v2(110.56,114.54)
  IN3 w0.135: v2(43.13,90.26) 42.96,90.09 42.46,90.09 41.65,89.29 41.65,85.96 39.09,83.4 39.09,82.07 37.04,80.02 37.04,72.97 29.18,65.11 29.18,59.23 23.53,53.58 23.53,49.26 21.64,47.37 16.28,47.37 15.58,46.67 15.58,45.23 v2(15.41,45.06)
  BOTTOM w0.076: UC1.C40 109.25,112.32 109.33,112.58 109.33,112.77 109.31,112.82 109.3,112.85 109.3,112.9 109.29,112.94 109.29,113.02 109.3,113.06 109.3,113.09 109.31,113.13 109.33,113.18 109.33,114.15 109.5,114.33 110.36,114.33 v2(110.56,114.54)
  BOTTOM w0.104: JNGFF3.55 15.45,44.47 15.6,44.62 15.6,44.87 v2(15.41,45.06)
CLK_PCIE_P4: length 225.7
  TOP w0.104: UL1.44 242.83,125.33 242.8,125.3 242.16,125.3 241.76,124.9 238.01,124.9 237.72,124.61 237.72,124.3 v2(237.48,124.05)
  IN1 w0.119: v2(110.51,115.67) 110.78,115.94 112.93,115.94 113.75,116.76 117.48,116.76 117.75,117.03 120.83,117.03 121.35,117.55 121.35,118.49 122.59,119.73 132.19,119.73 133.09,118.83 137.37,118.83 139.47,120.93 154.43,120.93 160.65,114.7 160.65,112.15 167.38,105.42 167.38,99.75 arc(169.79,87.66) 176.64,77.4 177.37,76.67 arc(185.98,70.92) 196.14,68.9 226.63,68.9 227.86,70.13 227.86,72.26 226.41,73.71 226.41,77.53 227.42,78.54 227.42,79.69 230.96,83.23 230.96,92.9 233.07,95.01 233.07,102.03 233.51,102.47 233.51,113.92 233.63,114.04 233.63,122.23 236.05,124.66 237.5,124.66 237.69,124.47 237.69,124.27 v2(237.48,124.05)
  BOTTOM w0.076: v2(110.51,115.67) 110.56,115.62 110.84,115.62 110.92,115.7 110.92,115.99 110.84,116.06 109.89,116.06 109.11,115.28 109.11,113.62 109.07,113.57 UC1.A40
CLK_PCIE_P5: length 109.4
  TOP w0.094: UT1.V19 31.96,104.89 31.67,105.19 v2(31.64,105.19)
  IN1 w0.076: v2(110.09,110.18) 110.09,110.37 109.99,110.47 109.87,110.47 109.73,110.33 109.73,109.31 108.81,108.4 108.81,107.63 108.65,107.47 108.65,107.44 108.64,107.43
  IN1 w0.119: 108.64,107.43 108.47,107.26 97.88,107.26 97.49,107.64 96.69,107.64 96.1,108.23 92.59,108.23 90.02,105.65 80.57,105.65 73.91,98.99 73.91,91.35 70.17,87.6 61.69,87.6 61.11,88.17 56.46,88.17 55.78,88.86 48.66,88.86 47.81,89.71 46.47,89.71 45.73,88.97 41.65,88.97 38.75,91.87 38.75,92.78 38.99,93.03 38.99,96.5 38.61,96.88 38.61,98.91 33.54,103.98 33.54,105.41 33.16,105.79 31.83,105.79 31.52,105.47 31.52,105.3 v2(31.64,105.19)
  BOTTOM w0.076: UC1.E38 v2(110.09,110.18)
CLK_TP_SIO_I2C_DAT: length 82.6
  TOP w0.112: UE1.E10 v2(249.48,91.46) ; v2(228.45,60.03) 228.5,60.07 228.5,60.23 227.94,60.78 219.18,60.78 218.23,59.83 v4(218.23,58.77) 218.23,57.18 217.91,56.86 217.55,56.86 v2(217.41,56.72) ; v2(212.33,55.5) 212.25,55.57 CZ81.1 RZ23.2 212.48,57.48 212.72,57.24 212.72,56.18 213.09,55.81 RZ346.1
  IN3 w0.135: v2(228.45,60.03) 228.62,60.2 228.62,60.73 230.82,62.93 235.87,62.93 237.42,64.47 239.98,64.47 240.23,64.73 240.23,65.25 241,66.02 241,68.04 243.94,70.98 243.94,73.34 243.55,73.73 243.55,80.88 243.13,81.3 243.13,85.35 242.99,85.48 241.58,85.48 241.21,85.86 241.21,88.86 243.99,91.65 243.99,93.57 245.74,95.32 247.34,95.32 247.62,95.03 248,95.03 248.7,94.34 248.7,93.3 248.28,92.89 248.28,92.06 248.49,91.86 249.08,91.86 v2(249.48,91.46)
  BOTTOM w0.112: v2(217.41,56.72) 217.18,56.95 214.96,56.95 214.36,56.35 213.18,56.35 v2(212.33,55.5)
CLK_TP_SIO_R: length 3.3
  TOP w0.112: v2(211.15,59.85) 211.15,58.62 RZ19.2 211.28,57.54 RZ23.1
  BOTTOM w0.112: JKBTP1.7 211.05,59.75 v2(211.15,59.85)
CLKDET#: length 9.8
  BOTTOM w0.076: UC1.AY8 127.79,92.01 127.79,90.92 128.57,90.13 129.11,90.13 130.33,88.91
  BOTTOM w0.112: 130.33,88.91 130.83,88.91 132.08,87.67 134.55,87.67 T258.1
CLKREQ_PCIE#0: length 229.3
  TOP w0.112: v2(270.83,67.05) 271.46,67.05 272.65,65.87 UR1.2 ; v2(146.56,92.37) 146.58,92.39 147.48,92.39 149.38,90.5 160.87,90.5 161.16,90.79 164.5,90.79 166.7,88.59 166.7,81.38 v2(166.56,81.25)
  IN1 w0.119: v2(232.98,114.45) 232.86,114.33 232.86,102.75 232.43,102.31 232.43,95.27 230.32,93.17 230.32,91.01 229.03,89.72 229.03,86.07 228.66,85.7 227.44,85.7 226.53,84.78 226.53,83.6 223.98,81.05 223.98,75.53 221.98,73.53 216.42,73.53 216.25,73.37 215.7,73.37 v2(215.42,73.65)
  IN2 w0.124: v2(147.6,96.99) 147.99,96.6 147.99,96.15 146.97,95.13 146.97,92.78 v2(146.56,92.37) ; v2(270.83,67.05) 271.5,67.73 271.5,77.05 268.21,80.33 268.21,83.7 267.16,84.75 267.16,86.45 267.53,86.82 267.9,86.82 270.42,89.34 271.35,89.34 271.83,89.82 271.83,91.22 272.37,91.76 272.37,94.75 268.54,98.58 267.74,98.58 263.42,102.9 261.82,102.9 259.27,105.44 256.41,105.44 255.76,106.1 248.32,106.1 245.41,109 244.4,109 240.32,113.08 240.32,114.95 240.09,115.18 233.71,115.18 v2(232.98,114.45)
  BOTTOM w0.112: v2(147.6,96.99) 147.17,97.42 RC373.1 ; v2(166.56,81.25) 166.71,81.39 v1(167.44,81.39) 173.05,81.39 185.16,69.28 211.36,69.28 215.47,73.39 215.47,73.6 v2(215.42,73.65)
CLKREQ_PCIE#0_R: length 24.1
  IN3 w0.135: v2(145.38,96.85) 144.15,95.63 132.04,95.63 130.34,97.32 127.56,97.32 127.09,96.85 127.09,95.88 127.49,95.48 v2(127.49,94.87)
  BOTTOM w0.102: UC1.AR10 127.26,95.1 v2(127.49,94.87)
  BOTTOM w0.112: RC189.1 144.81,97.42 v2(145.38,96.85) 145.95,97.42 RC373.2
CLKREQ_PCIE#1: length 113.5
  TOP w0.112: v2(174.65,70.34) v1(177.6,70.34) 178.44,70.34 181.51,67.27 184.45,67.27 187.94,65.81 226.77,65.81 227.98,67.02 231.21,67.02 v2(231.23,67)
  IN2 w0.124: v2(174.65,70.34) 174.27,69.96 173.63,69.96 173.35,70.25 162.33,70.25 160.85,71.73 151.95,71.73 150.39,73.29 150.39,83.24 145.59,88.04 145.59,94.4 v2(147.6,96.4)
  BOTTOM w0.112: RC374.1 147.04,96.4 v2(147.6,96.4) ; v2(231.23,67) 231.23,67.01 231.34,67.12 232.03,67.12 232.56,67.65 JNGFF1.53
CLKREQ_PCIE#1_R: length 22.4
  IN2 w0.124: v2(145.37,96.24) 145.19,96.07 144.03,96.07 142.91,94.94 140.57,94.94 136.65,91.03 130.86,91.03 129.85,92.03 129.85,93 v2(129.31,93.55)
  BOTTOM w0.097: UC1.AT7 129.31,93.98 v2(129.31,93.55)
  BOTTOM w0.112: RC374.2 145.66,96.53 v2(145.37,96.24) 145.08,96.53 RC47.1
CLKREQ_PCIE#2: length 123.4
  IN2 w0.124: v2(242.06,65.67) 241.32,65.67 240.95,65.29 237.6,65.29 236.37,64.07 233.63,64.07 233.12,63.56 230.46,63.56 230.16,63.25 204.43,63.25 203.05,64.63 185.06,64.63 183.11,66.58 176.43,66.58 174.9,68.11 174.9,69.33 175.04,69.47 175.04,70.8 174.76,71.08 169.74,71.08 168.39,72.44 168.39,77.52 167.41,78.49 167.41,81.68 165.19,83.9 165.19,86.7 163.74,88.15 160.53,88.15 159.88,88.8 153.94,88.8 153.29,88.15 150.25,88.15 148.13,90.27 148.13,94.33 v2(147.73,94.73)
  BOTTOM w0.112: RC375.1 146.91,95.54 v2(147.73,94.73) ; JNGFF1.68 241.62,63.9 241.91,64.19 241.91,65.52 v2(242.06,65.67)
CLKREQ_PCIE#2_R: length 23.5
  IN2 w0.124: v2(127.48,94.04) 128.26,93.27 128.26,92.87 130.32,90.8 136.74,90.8 140.63,94.69 143.01,94.69 144.13,95.81 145.21,95.81 v2(145.38,95.64)
  BOTTOM w0.097: UC1.AT8 127.51,94.04 v2(127.48,94.04)
  BOTTOM w0.112: RC375.2 v2(145.38,95.64) RC50.1
CLKREQ_PCIE#3: length 180.2
  TOP w0.112: v2(139.74,85.29) RC376.1
  IN1 w0.119: v2(145.19,65.45) 145.05,65.31 141.71,65.31 140.6,66.42 73.55,66.42 72.54,65.42 72.54,63.19 73.05,62.69 73.05,56.37 72.08,55.4 69.98,55.4 69.23,56.15 63.81,56.15 63.05,55.39 61.68,55.39 58.97,52.69 52.53,52.69 51.46,53.76 49.91,53.76 49.37,54.3 47.27,54.3 45.88,52.91 41.36,52.91 40.12,51.66 33.54,51.66 31.44,49.56 23.29,49.56 21.14,47.41 12.9,47.41 12.48,46.99 12.48,45.21 v2(14.38,43.32)
  IN3 w0.135: v2(14.38,43.32) 15.52,43.32 16.2,42.64 JNGFF3.52 ; v2(145.19,65.45) 145.4,65.67 145.4,68.6 143.36,70.65 143.36,77.68 143,78.04 142.49,78.04 142.16,78.37 142.16,78.73 141.86,79.03 141.5,79.03 139.74,80.8 v2(139.74,85.29)
CLKREQ_PCIE#3_R: length 19.9
  TOP w0.112: RC59.1 RC376.2 138.82,85.3 v2(138.77,85.35)
  IN3 w0.127: v2(126.57,94.08) 126.07,93.59 126.07,92.4 128.17,90.31 133.56,90.31
  IN3 w0.135: 133.56,90.31 138.52,85.35 v2(138.77,85.35)
  BOTTOM w0.097: v2(126.57,94.08) 126.94,94.45 UC1.AT10
CLKREQ_PCIE#4: length 164.4
  TOP w0.112: UL1.48 243.15,123.58 242.23,123.58 RL4.1 241.16,122.52 240.18,122.52 239.65,123.05 236.55,123.05 233.88,120.38 v1(233.88,117.74) 233.88,114.81 228.63,109.55 228.63,88.79 226.57,86.73 226.57,85.06 v2(227.42,84.21) ; v2(166.2,82.33) 166.2,88.64 164.31,90.54 161.31,90.54 161.02,90.24 148.2,90.24 146.68,91.76 v2(146.56,91.76)
  IN1 w0.119: v2(227.42,84.21) 227.42,83.26 224.84,80.68 224.84,75.19 222.33,72.68 211.94,72.68 211.81,72.55 v2(211.81,71.84)
  IN2 w0.124: v2(148.44,96.96) 148.22,96.73 148.22,96.04 147.2,95.03 147.2,94.17 147.7,93.67 147.7,91.7 147.5,91.5 146.81,91.5 v2(146.56,91.76)
  BOTTOM w0.112: RC377.1 147.09,98.31 v2(148.44,96.96) ; v2(211.81,71.84) 211.81,71.16 210.79,70.14 185.48,70.14 173.31,82.31 166.23,82.31 v2(166.2,82.33)
CLKREQ_PCIE#4_R: length 26.7
  IN2 w0.124: v2(127.48,93.4) 127.48,93.13 130.04,90.57 136.84,90.57 140.7,94.44 144.76,94.44 145.85,95.52 145.85,97.77 145.54,98.08 v2(145.37,98.08)
  BOTTOM w0.097: v2(127.48,93.4) 127.48,93.41 127.87,93.8 UC1.AU8
  BOTTOM w0.112: RC377.2 145.6,98.31 v2(145.37,98.08) 145.13,98.31 RC51.1
CLKREQ_PCIE#5: length 126.1
  TOP w0.076: 35.35,98.13 35.33,98.13 35.07,98.39 UT1.AC5
  TOP w0.112: RC378.1 139.74,81.28 140.11,80.91 140.68,80.91 140.87,80.72 141.9,80.72 142.65,79.97 v2(142.65,79.2) ; 35.35,98.13 v2(35.97,98.13)
  IN1 w0.119: v2(142.65,79.2) 142.45,79 141.15,79 140.49,78.34 140.49,77.68 139.77,76.96 88.24,76.96 80.1,85.1 73.89,85.1 73.87,85.08 60.45,85.08 59.84,85.69 54.94,85.69 v2(54.38,86.24) ; v2(43.41,91.2) 42.63,91.2 40.88,92.95 40.88,94 40.07,94.8 v2(40.07,95.11)
  BOTTOM w0.112: v2(43.41,91.2) 43.53,91.32 44.68,91.32 v1(44.96,91.05) 45.43,90.58 45.43,89.56 48.03,86.96 52.21,86.96 53.35,85.81 53.95,85.81 v2(54.38,86.24) ; v2(40.07,95.11) 40.07,95.12 37.2,95.12 36.69,95.64 36.69,97.23 35.97,97.95 v2(35.97,98.13)
CLKREQ_PCIE#5_R: length 17.7
  TOP w0.112: v2(128.78,93.28) 128.95,93.11 129.46,93.11 129.68,92.89 129.68,92.48 v1(129.91,92.25) 134.01,88.15 135.03,88.15 136.8,86.37 137.79,86.37 138.33,85.84 138.33,83.18 RC190.1 RC378.2
  BOTTOM w0.076: v2(128.78,93.28) 128.84,93.33 UC1.AU7
CLKRUN#: length 164.1
  TOP w0.107: v2(255.43,76.1) 255.99,76.66 RE337.1
  TOP w0.112: v2(136.61,85.1) RC27.1
  IN2 w0.124: v2(253.72,69.99) 251.18,69.99 249.48,68.29 248.01,68.29 244.88,65.16 244.88,63.69 242.55,61.36 242.55,60.35 241.88,59.68 236.16,59.68 234.96,58.49 228.95,58.49 227.38,60.06 226.65,60.06 225.78,60.94 219.24,60.94 218.28,59.97 216.29,59.97 215.09,58.78 208.41,58.78 207.76,59.43 206.89,59.43 206.26,60.06 204.17,60.06 202.03,62.2 182.64,62.2 182.34,62.49 181.25,62.49 180.38,63.37 178.86,63.37 178.34,62.85 174.03,62.85 170.93,65.94 162.84,65.94 159.32,69.46 150.74,69.46 150.24,69.96 149.91,69.96 147.7,72.17 147.7,79.97 143.1,84.57 137.15,84.57 v2(136.61,85.1)
  BOTTOM w0.076: 128.62,88.96 128.47,88.96 127.71,89.72 127.05,89.72 126.56,90.22 126.56,92.15 126.24,92.46 UC1.AW11
  BOTTOM w0.112: 128.62,88.96 131.32,86.27 v1(134.34,86.27) 135.06,85.55 136.17,85.55 v2(136.61,85.1) ; v2(255.43,76.1) 255.43,73.16 253.72,71.44 v2(253.72,69.99)
CLKRUN#_EC: length 7.6
  TOP w0.107: RE337.2 255.56,78.05 255.56,81.6 v1(255.41,81.74) 255.1,82.05 255.1,84.24 UE1.L2
CMOUT: length 13.8
  IN2 w0.124: v2(53.3,50.49) 53.56,50.76 59.18,50.76 v2(60.48,52.06)
  BOTTOM w0.112: PR951.1 52.16,52.09 52.16,51.26 52.28,51.13 ; v1(53.73,50.85) 53.38,50.49 v2(53.3,50.49) 53.28,50.48 PQ1210.3 52.3,50.48 52.16,50.62 52.16,51 52.28,51.13 ; v2(60.48,52.06) 60.56,51.97 PQ1216.2 ; PQ1210.2 52.28,51.13
COMP_IA: length 5.6
  TOP w0.203: PU602.16 53.42,94.37 v2(53.54,94.24)
  BOTTOM w0.112: v1(55.7,95.32) 55.07,95.32 53.99,94.24 v2(53.54,94.24)
  BOTTOM w0.203: v2(53.54,94.24) 53.24,94.55 PR639.2 52.12,94.55 PC636.2
COMP_ISL88738: length 2.9
  TOP w0.203: v2(56.09,53.72) 56.32,53.95 PU901.28
  BOTTOM w0.254: PR934.1 55.66,53.29 v2(56.09,53.72) PC943.1
COMP_VSA: length 4.3
  TOP w0.112: v2(51,97.88) 51.03,97.88 v1(51.56,98.41)
  TOP w0.203: PU602.24 50.73,97.61 v2(51,97.88)
  BOTTOM w0.203: PC628.1 49.99,97.23 PR630.1
  BOTTOM w0.229: v2(51,97.88) 50.64,97.88 50,97.24 PC628.1
CONTACTLESS_DET#: length 171.2
  TOP w0.112: v2(182.45,57.75) 181.53,57.75 179.83,56.04 179.83,53.84 181.2,52.47 184.97,52.47 187.51,49.93 219.53,49.93 v3(219.78,50.18) 220.87,51.27 v2(220.87,51.98)
  IN1 w0.119: v2(127.38,102.65) 127.81,102.22 130.96,102.22 131.57,102.83 134.72,102.83 135.84,101.71 137.01,101.71 140.13,98.59 141.77,98.59 v2(142.49,99.31)
  IN2 w0.124: v2(182.45,57.75) 182.14,57.43 180.01,57.43 179.5,57.95 178.1,57.95 176.01,55.85 164.83,55.85 161.44,59.24 148.41,59.24 146.68,60.97 146.68,64.51 145.16,66.03 145.16,67.57 142.34,70.39 142.34,71.84 138.59,75.59 138.59,80.41 140.08,81.9 v2(140.89,81.9)
  IN3 w0.135: v2(142.49,99.31) 142.69,99.51 144.27,99.51 145.21,100.45 145.61,100.45 146.26,99.79 146.83,99.79 147.33,99.29 148.64,99.29 149.28,98.65 149.28,96.95 149.02,96.68 149.02,95.63 148.72,95.33 148.72,94.92 149.26,94.37 149.26,92.93 148.85,92.52 148.85,92.13 144.83,88.11 144.83,85.04 143.64,83.85 141.77,83.85 141.2,83.27 141.2,82.21 v2(140.89,81.9)
  BOTTOM w0.076: UC1.W11 126.96,102.93 v2(127.38,102.65)
  BOTTOM w0.107: v2(220.87,51.98) 222.34,53.44 222.34,57.07 222.45,57.18 JUSH1.23
  BOTTOM w0.112: RC278.1 142.12,98.94 v2(142.49,99.31)
CORE_SNUB: length 3.2
  BOTTOM w0.112: v1(58.8,98.82) 59.52,99.54 59.52,101.33 59.24,101.61
CORE_SW:
  vias: v2(62.08,105.18)
CORE_VID0: length 72.2
  TOP w0.112: v2(156.13,130.12) 156.13,130.67 v1(156.08,130.72) 156.08,130.97 156.2,131.09 PR408.1
  IN1 w0.119: v2(138.58,125.85) 139.36,126.63 147.22,126.63 147.66,126.19 155.69,126.19 156.13,126.63 v2(156.13,130.12)
  IN2 w0.102: v2(126.5,96.05) 127.01,96.56 127.01,96.87 127.24,97.1 127.35,97.1
  IN2 w0.124: 127.35,97.1 127.37,97.09 130.04,97.09 131.61,95.51 136.04,95.51 136.8,96.28 136.8,97.61 137.91,98.72 137.91,102.63 138.52,103.23 138.76,103.23 140.13,104.6 140.13,105.55 139.63,106.06 139.63,107.95 137.48,110.1 137.48,111.39 136.52,112.35 136.52,117.84 138.64,119.96 138.64,121.29 137.07,122.86 137.07,125.31 136.98,125.4 136.98,126.01 137.25,126.27 138.16,126.27 v2(138.58,125.85)
  BOTTOM w0.102: v2(126.5,96.05) 126.45,96.05 UC1.AN11
CORE_VID1: length 80.7
  TOP w0.112: v2(136.33,125.85) v1(136.87,125.85)
  IN1 w0.119: v2(159.92,132.73) 158.71,132.73 156.6,130.62 149.17,130.62 147.47,128.92 147.47,127.71 146.71,126.95 138.96,126.95 138.58,127.33 135.03,127.33 134.64,126.95 134.64,126.25 135.04,125.85 v2(136.33,125.85)
  IN2 w0.076: 127.43,97.39 126.7,97.39 126.1,96.79 126.1,96.34 125.82,96.06 v2(124.8,96.06)
  IN2 w0.124: v2(136.33,125.85) 136.33,123.28 138.42,121.2 138.42,120.05 136.3,117.93 136.3,112.25 137.26,111.29 137.26,110.01 139.4,107.86 139.4,105.96 139.91,105.46 139.91,104.69 138.67,103.46 138.43,103.46 137.69,102.72 137.69,98.88 136.55,97.74 136.55,96.4 135.88,95.74 131.71,95.74 130.05,97.39 127.43,97.39
  BOTTOM w0.102: UC1.AN13 125.14,96.4 v2(124.8,96.06)
  BOTTOM w0.112: PR411.1 159.93,132.71 v2(159.92,132.73)
CPU_B+: length 15.1
  TOP w0.254: v2(46.58,98.51) 46.13,98.05 44.41,98.05 44.08,97.72 PR603.2
  IN3 w0.254: v2(53.87,104.53) 53.87,100.71 52.56,99.4 47.67,99.4 46.79,98.51 v2(46.58,98.51)
  vias: v2(53.87,107.07) v2(53.87,106.44) v2(53.87,105.8) v2(53.87,105.17) v2(63.91,111.91) v2(63.97,84.21) v2(63.97,83.58) v2(64.54,111.91) v2(64.6,84.21) v2(64.6,83.58) v2(65.24,84.21) v2(65.24,83.58) v2(65.87,84.21) v2(65.87,83.58) v2(66.51,84.21) v2(66.51,83.58) v3(63.14,88.28)
CPU_DP1_AUXN: length 119.6
  TOP w0.104: CT19.1 39.44,97.05 39.59,97.05 v2(39.9,96.74)
  IN1 w0.076: 103.51,111.88 103.51,111.87 103.54,111.85 103.54,111.8 103.56,111.78 103.56,111.62 103.16,111.22 103.16,109.94 103.38,109.71 103.54,109.71 v2(103.71,109.54)
  IN1 w0.119: 103.51,111.88 103.51,113.61 102.98,114.14 102.98,117.09 101.78,118.29 101.78,123.28 100.48,124.58 99.67,124.58 97.47,126.79 94.26,126.79 93.89,126.41 91.24,126.41 90.87,126.79 83.14,126.79 80.47,124.12 78.82,124.12 78.58,123.87 74.17,123.87 73.09,124.96 72.13,124.96 71.92,124.74 71.03,124.74 70.51,125.26 69.54,125.26 69.11,124.84 68.36,124.84 68.08,125.12 52.43,125.12 52.09,124.78 47.7,124.78 46.35,123.42 37,123.42 31.37,117.79 31.37,113.75 34.77,110.35 34.77,104.1 38.76,100.11 39.6,100.11 40.56,99.15 40.56,97.37 40.26,97.08 39.98,97.08 39.86,96.96 39.86,96.78 v2(39.9,96.74)
  BOTTOM w0.102: v2(103.71,109.54) 103.89,109.59 104.1,109.47 UC1.G50
CPU_DP1_AUXN_C: length 9.5
  TOP w0.094: v2(32.29,100.64) 32.61,100.96 UT1.W11
  TOP w0.104: v2(38.08,96.91) 38.28,97.1 38.53,97.1 CT19.2
  IN1 w0.119: v2(32.29,100.64) 32.29,100.32 32.8,99.8 35.71,99.8 36.43,99.08 36.43,97.84 37.37,96.91 v2(38.08,96.91)
CPU_DP1_AUXP: length 119.7
  TOP w0.104: v2(39.88,97.49) 39.66,97.27 39.52,97.27 CT18.1
  IN1 w0.076: v2(103.71,110.3) 103.73,110.27 103.73,110.02 103.6,109.89 103.46,109.89 103.33,110.01 103.33,111.15 103.73,111.55 103.73,111.88
  IN1 w0.119: 103.73,111.88 103.73,113.7 103.2,114.23 103.2,117.19 102,118.38 102,123.37 100.57,124.8 99.76,124.8 97.56,127 94.17,127 93.8,126.63 91.33,126.63 90.96,127 83.05,127 80.38,124.34 78.73,124.34 78.49,124.09 74.26,124.09 73.18,125.18 72.04,125.18 71.83,124.96 71.12,124.96 70.6,125.48 69.45,125.48 69.02,125.06 68.45,125.06 68.17,125.33 52.34,125.33 52,124.99 47.61,124.99 46.26,123.64 36.91,123.64 31.15,117.88 31.15,113.66 34.55,110.26 34.55,104.01 38.67,99.89 39.51,99.89 40.34,99.06 40.34,97.47 40.21,97.33 40.04,97.33 v2(39.88,97.49)
  BOTTOM w0.102: v2(103.71,110.3) 103.7,110.29 103.75,110.16 UC1.F50
CPU_DP1_AUXP_C: length 9.5
  TOP w0.094: UT1.Y11 33.1,100.96 32.94,100.8 v2(32.94,100.64)
  TOP w0.104: v2(38.08,97.49) 38.27,97.3 38.54,97.3 CT18.2
  IN1 w0.119: v2(38.08,97.49) 38.08,97.49 37.71,97.12 37.46,97.12 36.65,97.93 36.65,99.17 35.8,100.02 32.89,100.02 32.68,100.23 32.68,100.51 32.81,100.64 v2(32.94,100.64)
CPU_DP1_CTRL_CLK: length 120.7
  TOP w0.112: RT341.1 39.24,94.02 39.83,94.02 40.18,93.66 40.18,88.82 40.29,88.71 40.29,88.34 v2(39.88,87.92) ; RC175.1 131.82,110.15 131.82,111.31 130.57,112.57 128.5,112.57 127.42,111.49 127.42,110.83 127.08,110.5 127.08,107.89 v1(126.9,107.71) 126.8,107.61 125.48,107.61 v2(124.82,106.94)
  IN1 w0.076: 120.86,106.69 120.87,106.7 120.87,106.74 121.49,107.35 121.49,107.61 121.72,107.83 124.49,107.83 125.05,107.28 125.05,107.17 v2(124.82,106.94)
  IN1 w0.119: 120.86,106.69 120.64,106.47 120.64,106.3 119.23,104.89 119.23,103.64 117.05,101.46 117.05,100.43 116.27,99.65 107.92,99.65 103.48,95.21 100.58,95.21 98.73,93.36 98.73,91.35 96.49,89.11 90.35,89.11 88.87,87.64 81.28,87.64 79.77,89.15 73.73,89.15 70.83,86.25 60.96,86.25 60.37,86.84 55.83,86.84 55.14,87.52 42.76,87.52 42.65,87.64 40.82,87.64 40.37,88.09 40.05,88.09 v2(39.88,87.92)
  BOTTOM w0.102: UC1.L13 v2(124.82,106.94)
CPU_DP1_CTRL_DATA: length 119.8
  TOP w0.112: v2(39.88,88.51) 39.84,88.55 39.84,88.64 39.94,88.74 39.94,93.04 39.65,93.33 v2(39.65,93.43) ; v2(125.47,106.94) 125.88,107.35 127.3,107.35 127.98,108.02 127.98,110.5 127.66,110.82 127.66,111.39 128.5,112.23 v1(128.78,112.23) 130.57,112.23 131.59,111.21 131.59,109.5 RC178.1
  IN1 w0.076: v2(125.47,106.94) 125.25,107.17 125.25,107.36 124.57,108.04 121.63,108.04 121.28,107.69 121.28,107.44 120.73,106.88 120.7,106.88 120.68,106.87
  IN1 w0.119: 120.68,106.87 120.39,106.57 120.39,106.4 118.98,104.99 118.98,103.75 116.8,101.57 116.8,100.53 116.17,99.9 107.82,99.9 103.38,95.46 100.48,95.46 98.48,93.46 98.48,91.45 96.39,89.36 90.24,89.36 88.77,87.89 81.38,87.89 79.87,89.4 73.62,89.4 70.72,86.5 61.06,86.5 60.48,87.08 55.93,87.08 55.24,87.77 42.87,87.77 42.75,87.89 40.93,87.89 40.47,88.34 40.05,88.34 v2(39.88,88.51)
  BOTTOM w0.102: UC1.L12 v2(125.47,106.94)
  BOTTOM w0.112: RT342.1 39.39,93.43 v2(39.65,93.43)
CPU_DP1_HPD: length 166.7
  TOP w0.076: 34.48,95.49 34.29,95.49 34.06,95.72 34.06,95.97 33.72,96.31 33.72,96.79 UT1.AA2
  TOP w0.112: 34.48,95.49 34.7,95.49 36.3,93.89 37.21,93.89 37.81,93.29 38.39,93.29 RT24.1 39.05,92.8 v2(39.53,92.31)
  IN1 w0.119: v2(42.7,110.55) 42.24,110.09 42.24,102.68 42.68,102.23 42.68,98.75 39.63,95.7 39.63,94.89 40.31,94.21 40.31,93.1 v2(39.53,92.31)
  IN2 w0.124: v2(128.04,106.88) 128.53,106.39 129.41,106.39 129.75,106.73 129.75,109.18 130.17,109.6 130.17,113.6 129.44,114.34 129.44,115.82 129.94,116.33 132.43,116.33 132.69,116.59 132.69,118.3 132.1,118.89 132.1,121.65 132.56,122.11 132.56,123.22 131.17,124.61 128.44,124.61 128.01,124.18 120.98,124.18 119.85,125.31 118.6,125.31 116.67,123.38 109.83,123.38 109.55,123.1 103.96,123.1 102.82,124.24 99.08,124.24 97.94,123.1 89.4,123.1 88.53,122.24 86.82,122.24 86.72,122.33 85.92,122.33 84.89,121.3 72.84,121.3 72.04,122.1 71.03,122.1 69.24,123.89 62.3,123.89 59.51,121.09 55.87,121.09 53.56,123.4 47.5,123.4 46.91,122.81 41.25,122.81 40.94,122.51 40.94,121.02 42.49,119.47 44.3,119.47 45.33,118.43 45.33,115.07 42.7,112.43 v2(42.7,110.55)
  BOTTOM w0.076: v2(128.04,106.88) UC1.L9
CPU_DP1_N0: length 109.1
  TOP w0.104: v2(40.99,99.59) 40.8,99.4 37.6,99.4 CT11.1
  IN1 w0.076: v2(100.94,110.86) 100.96,110.83 100.96,110.61 100.89,110.54 100.78,110.54 100.77,110.53 100.73,110.53 100.56,110.69 100.56,111.09 100.65,111.17 100.65,111.26
  IN1 w0.119: 100.65,111.26 100.65,112.34 101.18,112.87 101.18,116.64 100.71,117.11 100.71,119.76 95.38,125.1 88.31,125.1 88.1,125.31 83.18,125.31 80.92,123.05 79.64,123.05 78.74,122.15 73.47,122.15 72.59,123.02 69.56,123.02 69.19,123.39 67.82,123.39 67.28,123.94 53.08,123.94 52.55,123.4 49.46,123.4 47.59,121.54 37.52,121.54 34.66,118.67 34.66,111.98 36.08,110.56 36.08,109.78 37.88,107.98 37.88,104.77 40.57,102.08 40.57,100.61 41.19,99.99 41.19,99.78 v2(40.99,99.59)
  BOTTOM w0.076: v2(100.94,110.86) 101,110.67 101.26,110.54 UC1.E55
CPU_DP1_N0_C: length 3.1
  TOP w0.076: UT1.AC7 34.29,99.31 34.21,99.4 34.21,99.47 34.28,99.55 34.59,99.55 34.71,99.43 35.35,99.43
  TOP w0.104: 35.35,99.43 36.64,99.43 CT11.2
CPU_DP1_N1: length 92.6
  TOP w0.104: CT13.1 39.08,100.19 40.07,100.19 40.85,100.96 41.58,100.96 v2(41.77,101.15)
  IN1 w0.119: v2(41.77,101.15) 41.96,101.35 41.96,101.93 41.5,102.39 41.5,111.22 42.4,112.12 42.4,114.28 47.88,119.76 48.86,119.76 50.96,121.85 66.56,121.85 66.99,121.42 71.05,121.42 71.63,120.85 79.31,120.85 79.96,121.5 82.11,121.5 84.64,124.03 87.49,124.03 88.13,123.38 88.96,123.38 89.44,122.9 94.1,122.9 95.14,121.86 95.14,121.3 97.06,119.37 98.96,119.37 99.43,118.91 99.43,113.01 97.8,111.38 97.8,110.66 98.07,110.4 98.81,110.4 98.93,110.53 98.93,110.63 v2(99.12,110.81)
  BOTTOM w0.089: UC1.E58 99.35,110.59 v2(99.12,110.81)
CPU_DP1_N1_C: length 4.5
  TOP w0.076: UT1.AC9 34.33,100.32 34.33,100.42 34.38,100.46 34.64,100.46 34.74,100.36 34.74,100.24 34.8,100.18 35.32,100.18 35.33,100.2 35.35,100.2
  TOP w0.104: 35.35,100.2 36.25,100.2 36.27,100.21 38.08,100.21 CT13.2
CPU_DP1_N2: length 109.4
  TOP w0.104: v2(39.68,101.21) 39.47,101 37.18,101 CT15.1
  IN1 w0.076: v2(101.88,110.22) 101.91,110.19 101.91,109.96 101.85,109.9 101.72,109.9 101.71,109.89 101.65,109.89 101.57,109.96 101.57,109.97 101.51,110.03 101.51,111.15 101.8,111.44 101.8,111.85 101.82,111.87 101.82,111.9
  IN1 w0.119: v2(39.68,101.21) 39.89,101.42 39.89,101.7 37.96,103.63 37.17,103.63 36.18,104.62 36.18,105.69 35.39,106.47 35.39,110.33 34.02,111.71 34.02,119 37.96,122.94 48,122.94 49.25,124.19 52.37,124.19 52.77,124.59 68.01,124.59 68.49,124.1 73.29,124.1 73.97,123.43 78.74,123.43 79,123.69 80.65,123.69 83.32,126.36 90.63,126.36 91.01,125.97 94.08,125.97 94.29,126.18 95.2,126.18 101.36,120.03 101.36,117.37 101.82,116.91 101.82,111.9
  BOTTOM w0.076: UC1.F53 101.9,110.16 v2(101.88,110.22)
