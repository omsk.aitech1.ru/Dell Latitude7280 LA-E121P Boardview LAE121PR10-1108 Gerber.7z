# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA9: length 43.6
  IN3 w0.076: 99.18,80.04 99.74,80.61 99.74,81.88 99.97,82.1 v2(100.22,82.1)
  IN3 w0.183: 99.18,80.04 99.18,79.74 99.36,79.55 99.89,79.55 100.07,79.37 100.07,79 99.89,78.82 98.95,78.82 98.73,78.6 98.73,69.6 99.43,68.9 99.43,68.49 103.5,64.42 103.5,62.36 104.33,61.53 104.33,59.35 104.51,59.16 v2(104.79,59.16)
  BOTTOM w0.076: v2(100.22,82.1) 99.97,81.85 99.64,81.85 99.57,81.93 99.57,83.55 99.99,83.98 99.99,87.37 101.93,89.3 101.93,90.34 101.82,90.44 UC1.BB54
  BOTTOM w0.183: JDIMM1.121 106.23,60.99 106.75,60.47 106.75,59.33 106.3,58.88 105.07,58.88 104.79,59.16 v2(104.79,59.16)
DDR_A_MA10: length 46.2
  IN3 w0.076: v2(103.69,94.04) 103.31,93.66 103.31,92.74 104.34,91.71 104.34,89.85 106.4,87.79 106.4,80.25 107.57,79.08 107.57,78.92
  IN3 w0.183: 107.57,78.92 107.57,71.15 113.57,65.15 113.57,58.97 113.53,58.92 113.53,58.38 113.88,58.02 v2(113.97,58.02)
  BOTTOM w0.076: v2(103.69,94.04) 103.69,94.07 104.15,94.41 UC1.AT50
  BOTTOM w0.183: v2(113.97,58.02) 113.51,57.56 113.51,55.6 114.48,54.64 JDIMM1.146
DDR_A_MA11: length 44.7
  IN3 w0.076: 97.79,77.35 97.79,79.81 99.24,81.26 99.24,81.93 v2(100.22,82.91)
  IN3 w0.183: 97.79,77.35 97.79,69.23 98.51,68.51 98.51,68.11 102.04,64.58 102.04,62.51 103.41,61.14 103.41,56.04 103.59,55.86 104.03,55.86 104.79,56.62 v2(104.79,56.62)
  BOTTOM w0.076: v2(100.22,82.91) 100.22,82.9 100.22,87.34 v4(101.51,88.62) 102.09,89.21 102.09,90.86 101.82,91.12 UC1.BA54
  BOTTOM w0.183: v2(104.79,56.62) 105.5,55.92 105.5,54.89 105.98,54.41 JDIMM1.120
DDR_A_MA12: length 45.5
  IN3 w0.076: v2(101.01,83.37) 101.38,83 101.38,81.58 100.67,80.88
  IN3 w0.183: 100.67,80.88 100.67,78.79 100.21,78.33 99.24,78.33 99.06,78.14 99.06,77.78 99.24,77.6 100.06,77.6 100.24,77.41 100.24,77.15 100.01,76.92 99.36,76.92 99.21,76.77 99.21,69.77 99.9,69.09 99.9,68.68 103.97,64.61 103.97,62.55 105.09,61.43 105.09,60.61 104.9,60.42 v2(104.79,60.42)
  BOTTOM w0.076: UC1.AW54 101.4,92.64 101.33,92.56 101.33,92.42 101.43,92.32 101.95,92.32 102.03,92.23 102.03,91.56 102.26,91.34 102.26,89.02 100.39,87.15 100.39,83.88 100.9,83.37 v2(101.01,83.37)
  BOTTOM w0.183: JDIMM1.119 105.73,60.83 106.31,60.25 106.31,59.51 106.12,59.32 105.42,59.32 105.24,59.5 105.24,60.12 104.94,60.42 v2(104.79,60.42)
DDR_A_MA13: length 48.1
  IN3 w0.076: v2(105.52,93.52) 105.52,93.2 107.64,91.09 107.64,81.1 109.88,78.86 109.88,78.52
  IN3 w0.183: 109.88,78.52 109.88,72.12 115.88,66.12 115.88,61.7 116.88,60.7 116.88,59.15 116.05,58.32 116.05,56.17 116.33,55.89 116.76,55.89 116.94,56.07 v2(116.94,56.78)
  BOTTOM w0.076: UC1.AU46 105.7,93.52 v2(105.52,93.52)
  BOTTOM w0.183: JDIMM1.158 117.48,56.14 116.94,56.68 v2(116.94,56.78)
DDR_A_MA14: length 44.7
  IN3 w0.076: v2(105.52,94.1) 105.23,94.1 105.15,94.03 105.15,93.2 107.39,90.97 107.39,80.98 109.42,78.96 109.42,78.65
  IN3 w0.183: v2(116.39,59.93) 116.39,59.92 115.99,59.53 115.69,59.53 115.42,59.81 115.42,60.25 115.6,60.43 115.76,60.43 115.94,60.61 115.94,60.98 115.76,61.16 115.6,61.16 115.42,61.34 115.42,65.93 109.42,71.93 109.42,78.65
  BOTTOM w0.076: UC1.AT46 106.04,94.39 106.04,94.26 105.78,93.99 105.58,93.99 105.52,94.05 v2(105.52,94.1)
  BOTTOM w0.183: v2(116.39,59.93) 116.39,59.9 116.2,59.71 115.94,59.71 115.46,60.2 115.46,60.63 115.73,60.9 JDIMM1.151
DDR_A_MA15: length 45.6
  IN3 w0.076: v2(104.61,93.47) 104.61,93.06 105.48,92.19 105.48,89.87 106.91,88.45 106.91,80.67 108.49,79.08 108.49,78.82
  IN3 w0.183: v2(115.6,57.39) 115.3,57.39 115.1,57.59 115.1,58.82 114.49,59.42 114.49,65.53 108.49,71.53 108.49,78.82
  BOTTOM w0.076: v2(104.61,93.47) UC1.AU48
  BOTTOM w0.183: v2(115.6,57.39) 115.6,57.38 116.98,56.01 JDIMM1.156
DDR_A_MA16: length 45.4
  IN3 w0.076: 108.03,78.82 108.03,79.01 106.65,80.38 106.65,88.35 105.26,89.75 105.26,91.15 103.98,92.42 103.98,93.17 v2(103.69,93.46)
  IN3 w0.183: 108.03,78.82 108.03,71.34 114.03,65.34 114.03,59.23 114.47,58.79 114.47,57.24 115.59,56.12 v2(115.6,56.12)
  BOTTOM w0.076: UC1.AU50 103.69,93.47 v2(103.69,93.46)
  BOTTOM w0.183: v2(115.6,56.12) 115.98,55.74 JDIMM1.152
DDR_A_ODT0: length 50
  IN3 w0.076: 110.8,78.47 110.8,78.75 108.74,80.82 108.74,91.48 106.91,93.3 106.91,93.75 v2(107.33,94.17)
  IN3 w0.183: 110.8,78.47 110.8,72.51 117.28,66.03 117.28,63.11 117.47,62.93 118.64,62.93 118.82,62.74 118.82,62.38 118.64,62.2 117.47,62.2 117.28,62.01 117.28,61.61 117.6,61.28 118.64,61.28 118.82,61.1 118.82,60.61 118.55,60.34 117.99,60.34 117.81,60.15 117.81,59.34 v2(118.11,59.04)
  BOTTOM w0.076: v2(107.33,94.17) 107.53,94.37 107.53,94.92 107.42,95.03 107.21,95.03 106.89,94.71 UC1.AT45
  BOTTOM w0.183: v2(118.11,59.04) 117.85,59.3 117.27,59.3 117.02,59.55 117.02,60.13 116.89,60.26 116.89,60.74 116.73,60.91 JDIMM1.155
DDR_A_ODT1: length 52.4
  IN3 w0.076: 111.73,78.24 111.73,78.54 109.14,81.12 109.14,91.79 108.72,92.21 108.72,93.97 108.64,94.04 v2(108.26,94.04)
  IN3 w0.183: v2(119.85,58.37) 119.75,58.27 119.49,58.27 119.05,58.71 119.05,59.53 119.75,60.23 119.75,60.57 119.96,60.78 119.96,61.3 119.75,61.51 119.75,62.03 119.96,62.25 119.96,62.76 119.75,62.98 119.75,63.56 119.96,63.78 119.96,66.07 119.78,66.25 119.31,66.25 119.12,66.07 119.12,64.48 118.94,64.3 118.57,64.3 118.39,64.48 118.39,66.81 118.21,66.99 117.62,66.99 111.73,72.89 111.73,78.24
  BOTTOM w0.102: UC1.AT43 107.75,94.39 107.76,94.24 107.99,94.03 v2(108.26,94.04)
  BOTTOM w0.183: JDIMM1.161 118.23,61.9 118.23,60.75 119,59.98 119,58.57 119.33,58.24 119.72,58.24 v2(119.85,58.37)
DDR_A_PARITY: length 42.7
  IN3 w0.076: 105.96,79.81 105.84,79.93 105.84,87.7 103.86,89.68 103.86,91.5 102.39,92.97 102.39,94.09 102.47,94.17 102.65,94.17 v2(102.78,94.04)
  IN3 w0.183: 105.96,79.81 106.64,79.13 106.64,70.74 112.64,64.74 112.64,64.37 112.32,64.05 112.32,63.73 112.64,63.41 112.64,63.1 112.32,62.78 112.32,61.93 112.64,61.61 112.64,60.92 112.48,60.75 v2(112.31,60.75)
  BOTTOM w0.076: UC1.AT52 103.31,94.38 103.31,94.27 102.97,93.93 102.89,93.93 v2(102.78,94.04)
  BOTTOM w0.183: v2(112.31,60.75) 112.29,60.75 111.78,60.24 111.52,60.24 111.3,60.46 111.3,60.71 111.73,61.14 JDIMM1.143
DDR_DRAMRST#: length 91.6
  TOP w0.112: RD11.2 RD12.2 104.49,52.44 v2(104.96,51.97)
  IN1 w0.119: v2(137.31,82.12) 137.31,83.2 134.33,86.18 134.33,87.07 133.06,88.34 129.88,88.34 125.25,92.97 125.25,93.69 v2(124.8,94.13)
  IN3 w0.135: v2(104.96,51.97) 104.96,53.39 106.13,54.56 137.5,54.56 137.92,54.98 142.56,54.98 143.13,55.55 143.13,58.18 143.71,58.76 143.71,64.25 143.22,64.74 143.22,68.07 141.41,69.87 141.41,73.71 138.02,77.1 138.02,78.37 137.62,78.76 137.62,79.64 136.8,80.47 136.8,81.61 v2(137.31,82.12)
  BOTTOM w0.076: UC1.AT13 124.86,94.13 v2(124.8,94.13)
DDR_DRAMRST#_R: length 4.6
  TOP w0.112: RD12.1 102.74,52.59 CD29.1 102.46,52.39 102.11,52.39 v2(102.03,52.46) 101.99,52.5 101.99,53.06 v1(101.76,53.29)
  BOTTOM w0.112: v2(102.03,52.46) 102.54,52.46 102.98,52.9 JDIMM1.108
DDR_VTT_CTRL: length 26.7
  BOTTOM w0.076: UC1.AW67 93.77,92.63 93.67,92.73 93.03,92.73 92.97,92.8 91.7,92.8 91.4,92.5 90.73,92.5 90.18,91.95 90.18,91.73 89.82,91.37
  BOTTOM w0.112: 89.82,91.37 89.7,91.25 89.7,90.07 88.51,88.87 88.51,88.52 88.09,88.1 83.93,88.1 80.22,84.4 v1(74.01,84.4) 73.98,84.4 73.09,83.51 UD1.2
DDR_XDP_WAN_SMBCLK: length 152.4
  IN1 w0.119: v2(150.27,110.37) 150.46,110.18 150.46,109.26 151.57,108.15 151.57,106.36 153.38,104.56 153.38,100.75 154.21,99.92 154.21,95.85 153.58,95.22 153.58,89.6 153.26,89.28 152.61,89.28 v2(152.44,89.45)
  IN3 w0.135: v2(87.91,128.79) 88.07,128.95 88.07,129.31 88.97,130.21 103.41,130.21 105.59,128.03 113.69,128.03 113.88,127.84 116.73,127.84 118.19,126.38 119.61,126.38 121.52,124.47 121.52,119.35 122.03,118.84 122.03,117.3 123.87,115.46 124.35,115.46 126.11,113.7 130.09,113.7 131.56,115.17 135.76,115.17 140.64,110.3 146.38,110.3 146.83,110.74 148.51,110.74 149.56,109.7 150.15,109.7 150.45,110 150.45,110.19 v2(150.27,110.37) ; v2(152.44,89.45) 152.28,89.29 152.08,89.29 150.82,90.55 150.06,90.55 147.01,87.5 147.01,85.9 146.16,85.05 146.16,80.69 145.15,79.68 145.15,71.38 147.31,69.22 147.31,65.83 147.13,65.65 147.13,62.86 147.98,62.01 147.98,58.52 147.75,58.29 147.6,58.29 v2(147.44,58.45)
  BOTTOM w0.112: v2(147.44,58.45) 147.27,58.28 145.46,58.28 144.83,58.91 143.05,58.91 141.23,60.74 JDIMM1.253 ; v2(87.91,128.79) 88.1,128.98 88.1,129.17 87.91,129.36 JXDP1.53 ; QC2.1 150.84,109.75 150.27,110.33 v2(150.27,110.37) 150.27,110.93 RC319.1
DDR_XDP_WAN_SMBDAT: length 159.3
  IN1 w0.119: v2(152.44,88.87) 152.61,89.04 153.36,89.04 153.83,89.5 153.83,95.11 154.46,95.74 154.46,100.02 153.62,100.86 153.62,104.66 151.82,106.47 151.82,108.25 150.71,109.36 150.71,110.18 v2(150.9,110.37)
  IN3 w0.135: v2(152.44,88.87) 152.28,89.03 151.97,89.03 150.71,90.29 150.16,90.29 147.27,87.39 147.27,85.79 146.42,84.94 146.42,80.58 145.41,79.57 145.41,71.49 147.57,69.33 147.57,65.72 147.39,65.54 147.39,62.96 148.24,62.12 148.24,58.41 147.86,58.03 147.6,58.03 v2(147.44,57.87) ; v2(88.5,128.79) 88.34,128.95 88.34,129.2 89.08,129.95 103.3,129.95 105.48,127.77 113.58,127.77 113.77,127.57 116.62,127.57 118.08,126.12 119.51,126.12 121.26,124.36 121.26,119.24 121.77,118.73 121.77,117.2 123.76,115.2 124.24,115.2 126,113.44 130.2,113.44 131.67,114.91 135.65,114.91 140.53,110.03 146.49,110.03 146.93,110.48 148.4,110.48 149.45,109.44 150.26,109.44 150.71,109.89 150.71,110.19 v2(150.9,110.37)
  BOTTOM w0.112: v2(150.9,110.37) 151.36,110.37 151.47,110.26 151.47,108.31 151.22,108.06 150.17,108.06 149.88,108.34 149.45,108.34 149.34,108.45 QC2.4 148.61,108.45 RC318.1 ; JXDP1.51 88.51,129.34 88.34,129.17 88.34,128.95 v2(88.5,128.79) ; v2(147.44,57.87) 147.27,58.04 145.37,58.04 144.73,58.67 143.08,58.67 142.26,57.86 142.26,55.38 141.48,54.59 JDIMM1.254
DEBUG_TX: length 3.8
  BOTTOM w0.112: JDEG1.9 290.58,122.34 289.85,121.61 289.53,121.61 RE30.2 RE74.2 v1(289.28,119.49)
DIMM1_SA0: length 5.3
  TOP w0.112: RD4.2 144.42,56.77 v2(143.98,56.77) 143.53,56.77 RD5.1
  BOTTOM w0.112: v2(143.98,56.77) 141.98,54.76 JDIMM1.256
DIMM1_SA1: length 4.5
  TOP w0.112: RD7.1 143.55,55.7 v2(143.99,56.14) 144.44,55.7 RD6.2
  BOTTOM w0.112: JDIMM1.260 142.98,55.13 v2(143.99,56.14)
DIMM1_SA2: length 5.5
  TOP w0.112: RD9.1 RD8.2 v2(121.63,51.83) v1(121.12,51.83)
  BOTTOM w0.112: JDIMM1.166 119.48,52.9 120.55,51.83 v2(121.63,51.83)
DISP_ON: length 17.2
  TOP w0.112: RV2.1 72.61,122.68 DV2.1 72.53,123.33 71.73,124.13 70.45,124.13 v2(69.77,124.82)
  BOTTOM w0.112: JEDP1.22 61.75,132.24 63.96,130.03 63.96,128.34 67.48,124.82 v1(68.26,124.82) v2(69.77,124.82)
DMIC0: length 314.1
  TOP w0.112: UA1.2 259.13,63.81 259.75,64.44 259.75,65.26 RA52.2 259.09,65.93 259.09,67.43 259.34,67.69 259.34,69.17 259.68,69.51 260.07,69.51 v2(260.25,69.33) ; v2(40.75,82.81) 40.75,83.06 40.48,83.34 40.48,85.47 41.43,86.42 41.43,89.19 41.31,89.3 41.31,97.88 42.84,99.41 42.84,104.23 41.27,105.8 41.27,111.04 48.65,118.42 52.03,118.42 53.57,119.96 53.57,120.9 v4(54.35,121.68) 55.07,122.4 55.07,124.79 54.16,125.7 54.16,128.13 CA6.1 53.29,129 53.29,129.88 53.53,130.12 v2(53.76,130.12)
  IN1 w0.119: v2(260.25,69.33) 260.07,69.5 259.34,69.5 258.93,69.92 256.45,69.92 256,70.38 251.7,70.38 249.76,68.45 248.6,68.45 245.41,65.26 244.94,65.26 242.45,62.77 237.88,62.77 236.55,61.43 236.55,60.87 236.09,60.41 236.09,58.26 233.1,55.27 229.17,55.27 227.99,56.45 227.99,58.43 227.67,58.75 224.56,58.75 223.93,58.12 215.86,58.12 215.14,57.4 207.63,57.4 206.46,58.57 202.95,58.57 202.23,57.85 196.06,57.85 195.16,58.76 182.85,58.76 181.82,57.73 180.16,57.73 179.05,58.84 177.02,58.84 176.4,59.45 172.24,59.45 168.2,63.49 162.71,63.49 162.39,63.82 156.88,63.82 156.28,63.22 148.2,63.22 147.03,64.39 147.03,66.85 145.67,68.21 87.48,68.21 76.93,78.76 57.44,78.76 56.61,77.93 45.02,77.93 40.91,82.04 40.91,82.65 v2(40.75,82.81)
  BOTTOM w0.107: v2(53.76,130.12) 53.76,130.58 54.25,131.07 JEDP1.7
DMIC_CLK0: length 310.8
  TOP w0.112: RA14.1 CA54.1 259.1,67.82 259.1,69.27 259.58,69.74 260.08,69.74 v2(260.25,69.91) ; v2(54.37,130.12) 53.76,129.51 CA5.1 54.4,128.77 54.4,125.8 55.31,124.89 55.31,122.3 53.81,120.8 53.81,119.86 52.13,118.18 48.75,118.18 41.51,110.94 41.51,105.9 43.08,104.33 43.08,99.31 41.55,97.79 41.55,89.4 41.66,89.29 41.66,86.32 40.71,85.37 40.71,83.44 v2(41.34,82.81)
  IN1 w0.119: v2(260.25,69.91) 260.09,69.75 259.44,69.75 259.03,70.17 256.56,70.17 256.1,70.62 251.59,70.62 249.66,68.69 248.49,68.69 245.31,65.51 244.83,65.51 242.34,63.02 237.78,63.02 236.3,61.54 236.3,60.98 235.84,60.52 235.84,58.36 233,55.52 229.27,55.52 228.24,56.55 228.24,58.53 227.77,58.99 224.46,58.99 223.83,58.37 215.76,58.37 215.04,57.64 207.73,57.64 206.56,58.81 202.84,58.81 202.13,58.1 196.16,58.1 195.26,59 182.75,59 181.72,57.97 180.26,57.97 179.15,59.08 177.12,59.08 176.5,59.7 172.34,59.7 168.3,63.74 162.81,63.74 162.49,64.06 156.78,64.06 156.18,63.47 148.3,63.47 147.27,64.5 147.27,66.95 145.77,68.46 87.58,68.46 77.03,79 57.33,79 56.51,78.18 45.12,78.18 41.16,82.14 41.16,82.64 v2(41.34,82.81)
  BOTTOM w0.107: v2(54.37,130.12) 54.37,130.49 55.25,131.37 JEDP1.9
DMIC_CLK_CODEC: length 2.4
  TOP w0.112: RA14.2 259.1,64.96 v1(259.1,64.55) 259.1,64.35 258.73,63.97 UA1.3
DPSNK0_DDC_CLK: length 10.2
  TOP w0.102: UT1.Y5 v2(32.94,98.68)
  TOP w0.112: RT126.1 38.11,94.66 RT341.2 ; RT126.1 RT14.1 ; RT126.1 37.5,94.68 v2(37.49,94.69)
  IN1 w0.119: v2(37.49,94.69) 37.17,95.01 34.76,95.01 34,95.77 34,97.63 32.94,98.68 v2(32.94,98.68)
DPSNK0_DDC_DATA: length 13.4
  TOP w0.102: UT1.R4 v2(30.34,98.04)
  IN1 w0.119: v2(30.34,98.04) 30.34,97.33 30.73,96.94 32.45,96.94 34.63,94.75 36.6,94.75 v2(36.96,94.4)
  BOTTOM w0.102: RT15.1 39.72,94.68 v3(40.09,94.31)
  BOTTOM w0.112: v2(36.96,94.4) 37.55,93.8 RT342.2 38.12,93.81 RT127.1 RT15.1
DPSNK1_DDC_CLK: length 11.8
  TOP w0.076: UT1.Y8 33.01,99.92 31.92,99.92 31.64,100.2 v2(31.64,100.65)
  IN3 w0.135: v2(31.64,100.65) 32.13,100.16 34.52,100.16 v2(35.97,98.72)
  BOTTOM w0.112: v1(38.17,100.47) RT336.1 37.51,99.49 RT128.1 35.97,99.26 v2(35.97,98.72)
DPSNK_RBIAS: length 4.1
  TOP w0.102: UT1.Y18 v2(32.94,103.89)
  BOTTOM w0.112: v2(32.94,103.89) 33.24,103.89 RT38.1 34.15,104.8 34.15,106.09 v1(33.62,106.63)
EC_FPM_EN: length 46.8
  TOP w0.107: UE1.D6 v2(248.68,87.46)
  TOP w0.112: v1(231.29,59.18) 231.68,59.57 v2(231.68,60.06)
  IN3 w0.135: v2(248.68,87.46) 248.51,87.46 248.11,87.06 247.67,87.06 247.48,86.87 247.48,82.77 247.45,82.74 247.45,81.14 247.76,80.82 247.76,79.12 247.14,78.5 246.89,78.5 245.79,77.4 245.79,75.98 246.91,74.86 246.91,70.19 246.54,69.82 246.54,67.21 242.97,63.64 242.97,60.75 241.12,58.9 234.22,58.9 233.77,59.36 232.96,59.36 232.74,59.57 232.74,60.33 232.6,60.46 232.08,60.46 v2(231.68,60.06)
  BOTTOM w0.112: JUSH1.5 231.45,59.83 v2(231.68,60.06)
EDP_AUXN: length 62.9
  TOP w0.104: CV1.1 67.39,128.53 67.74,128.53 69.6,126.67 72.08,126.67 72.57,127.17 75.07,127.17 76.16,126.08 76.16,125.93 75.97,125.74 v2(75.95,125.74)
  IN1 w0.076: v2(106.48,110.86) 106.54,110.8 106.54,110.7 106.38,110.54 106.2,110.54 106.12,110.62 106.12,111.84 106.14,111.86 106.14,111.88
  IN1 w0.119: 106.14,111.88 106.14,112.23 106.87,112.97 106.87,114.1 106.97,114.2 106.97,117.5 107.4,117.93 107.4,121.23 107.51,121.34 107.51,124.46 104.6,127.36 104.6,128.61 103.65,129.57 83.68,129.57 80.22,126.11 76.91,126.11 76.53,125.73 75.96,125.73 v2(75.95,125.74)
  BOTTOM w0.089: v2(106.48,110.86) 106.75,110.59 UC1.E45
EDP_AUXN_C: length 3.2
  TOP w0.104: CV1.2 67.31,130.24 67.31,130.66 v2(67.11,130.86)
  BOTTOM w0.104: v2(67.11,130.86) 67.31,131.06 67.31,131.53 67.41,131.62 67.41,131.97 67.25,132.12 JEDP1.33
EDP_AUXP: length 62.8
  TOP w0.104: CV2.1 67.84,128.71 69.68,126.87 72,126.87 72.49,127.37 75.15,127.37 76.36,126.16 76.36,125.39 v2(76.17,125.2)
  IN1 w0.076: v2(106.48,110.2) 106.32,110.36 106.12,110.36 105.94,110.54 105.94,111.84 105.92,111.86 105.92,111.88
  IN1 w0.119: v2(76.17,125.2) 76.27,125.11 76.55,125.11 76.67,125.23 76.67,125.56 77,125.89 80.32,125.89 83.77,129.35 103.55,129.35 104.38,128.52 104.38,127.27 107.29,124.37 107.29,121.43 107.18,121.32 107.18,118.02 106.75,117.59 106.75,114.29 106.66,114.19 106.66,113.06 105.92,112.32 105.92,111.88
  BOTTOM w0.089: UC1.F45 106.89,110.06 106.75,110.2 v2(106.48,110.2)
EDP_AUXP_C: length 3.2
  TOP w0.104: CV2.2 67.51,130.21 67.51,130.68 v2(67.69,130.86)
  BOTTOM w0.104: v2(67.69,130.86) 67.51,131.04 67.51,131.44 67.61,131.54 67.61,131.98 67.75,132.13 JEDP1.34
EDP_BIA_PWM: length 94.9
  TOP w0.112: v2(73.58,122.67) 73.24,123.01 73.24,126.41 73.5,126.68 74.35,126.68 DV1.3
  IN2 w0.124: v2(73.58,122.67) 74.5,121.75 81.5,121.75 82.18,122.43 85.28,122.43 86.41,123.56 97.76,123.56 99.05,124.85 105.05,124.85 105.15,124.95 117.61,124.95 118.42,125.77 120.03,125.77 121.17,124.63 127.82,124.63 128.38,125.19 132.84,125.19 133.25,124.78 133.25,121.73 132.82,121.3 132.82,119.14 134.1,117.85 134.1,115.11 131.74,112.75 131.74,105.8 130.34,104.4 127.36,104.4 v2(126.92,104.84)
  BOTTOM w0.102: UC1.R11 126.92,104.85 v2(126.92,104.84)
EDP_COMP: length 2.2
  TOP w0.127: v2(102.7,110.93) v1(102.7,111.45)
  TOP w0.381: v2(102.7,110.93) 102.7,110.03 RC2.1
  BOTTOM w0.254: UC1.E52 103.04,110.59 v2(102.7,110.93)
EDP_HPD: length 106.9
  TOP w0.107: RV7.1 v2(64.21,131.53)
  TOP w0.112: v2(127.4,106.88) 127.4,106.61 127.19,106.4 RC1.1
  IN2 w0.124: v2(127.4,106.88) 127.23,106.71 127.23,105.65 127.52,105.36 129.6,105.36 130.11,105.87 130.11,108.1 130.75,108.74 130.75,109.25 130.4,109.6 130.4,113.73 129.69,114.44 129.69,115.76 130.03,116.1 132.52,116.1 132.92,116.5 132.92,118.39 132.36,118.95 132.36,121.56 132.79,121.99 132.79,123.31 131.26,124.84 128.34,124.84 127.91,124.41 121.07,124.41 119.94,125.54 118.51,125.54 117.67,124.7 105.26,124.7 105.18,124.62 99.14,124.62 97.85,123.33 89.23,123.33 88.37,122.46 86.94,122.46 86.82,122.59 85.8,122.59 85.41,122.2 82.27,122.2 81.59,121.52 74.08,121.52 70.81,124.8 v2(70.37,124.8)
  BOTTOM w0.076: v2(127.4,106.88) UC1.L10
  BOTTOM w0.107: v2(64.21,131.53) 63.75,131.99 JEDP1.26
  BOTTOM w0.112: v2(64.21,131.53) 64.21,128.47 67.43,125.25 69.92,125.25 v2(70.37,124.8)
EDP_TXN0: length 55.3
  TOP w0.104: v2(77.78,125.47) 77.69,125.55 77.69,126.35 76.81,127.24 76.14,127.24 75.38,128 72.23,128 71.71,127.48 69.93,127.48 69.23,128.19 69.23,128.65 69.54,128.97 CV4.1
  IN1 w0.119: v2(105.61,115.94) 105.23,115.56 105,115.56 104.29,116.28 104.29,122.83 101.59,125.53 100.13,125.53 97.94,127.72 82.75,127.72 80.09,125.05 78.43,125.05 78.21,124.83 77.53,124.83 77.42,124.94 77.42,125.11 77.78,125.47 v2(77.78,125.47)
  BOTTOM w0.076: UC1.C47 105.72,112.27
  BOTTOM w0.089: 105.72,112.27 105.72,113.47 105.06,114.13 105.06,115.5 105.3,115.75 105.41,115.75 v2(105.61,115.94)
EDP_TXN0_C: length 3.5
  TOP w0.104: v2(69.47,130.86) 69.29,130.68 69.29,130.21 CV4.2
  BOTTOM w0.104: JEDP1.36 68.75,132.14 68.58,131.96 68.58,131.91 69.26,131.23 69.26,131.06 v2(69.47,130.86)
EDP_TXN1: length 53.6
  TOP w0.104: v2(83.95,128.91) 84.04,128.91 84.13,128.82 84.13,128.73 84.34,128.52 84.34,128.37 83.92,127.95 76.29,127.95 75.63,128.61 71.98,128.61 71.46,128.09 70.9,128.09 70.79,128.21 70.79,128.45 70.89,128.56 71.29,128.56 71.4,128.66 CV6.1
  IN1 w0.119: v2(83.95,128.91) 84.06,128.81 84.06,128.39 84.3,128.15 98.21,128.15 100.31,126.05 101.79,126.05 104.71,123.13 104.71,117.41 105,117.12 v2(105.61,117.12)
  BOTTOM w0.076: v2(105.61,117.12) 105.88,117.39 106.2,117.39 106.52,117.07 106.52,113.88 106.64,113.76 106.65,113.76 106.86,113.55 106.86,113.21 106.84,113.16 106.84,112.79 106.85,112.77 106.85,112.58 106.77,112.32 106.74,112.29 106.47,112.29 106.31,112.13 106.31,111.97 UC1.D46
EDP_TXN1_C: length 4.4
  TOP w0.104: CV6.2 71.04,130.24 71.04,130.66 v2(71.25,130.86)
  BOTTOM w0.104: JEDP1.38 69.75,132.17 69.59,132.01 69.59,131.77 69.83,131.53 70.81,131.53 71.07,131.28 71.07,131.04 v2(71.25,130.86)
EDP_TXP0: length 55.3
  TOP w0.104: v2(77.19,125.47) 77.49,125.77 77.49,126.27 76.73,127.04 76.06,127.04 75.3,127.8 72.31,127.8 71.8,127.28 69.85,127.28 69.03,128.1 69.03,128.67 CV3.1
  IN1 w0.119: v2(105.61,115.35) 104.91,115.35 104.07,116.18 104.07,122.74 101.5,125.31 100.04,125.31 97.85,127.5 82.84,127.5 80.18,124.84 78.52,124.84 78.3,124.61 77.44,124.61 77.19,124.86 v2(77.19,125.47)
  BOTTOM w0.089: v2(105.61,115.35) 105.61,115.46 105.5,115.56 105.38,115.56 105.25,115.43 105.25,114.21 105.91,113.54 105.91,112.72 105.97,112.65 106.23,112.65 106.34,112.54 106.34,112.4 106.21,112.28 106.09,112.28 UC1.C46
EDP_TXP0_C: length 3.5
  TOP w0.104: CV3.2 69.09,130.24 69.09,130.66 v2(68.88,130.86)
  BOTTOM w0.104: v2(68.88,130.86) 69.06,131.04 69.06,131.15 68.38,131.83 68.38,132.01 68.25,132.14 JEDP1.35
EDP_TXP1: length 53.5
  TOP w0.104: CV5.1 70.59,128.89 70.59,128.12 70.82,127.89 71.55,127.89 72.06,128.41 75.55,128.41 76.21,127.75 84,127.75 84.54,128.29 84.54,128.9 v2(84.54,128.9)
  IN1 w0.119: v2(105.61,117.77) 105.51,117.67 105.51,117.59 105.46,117.53 105.43,117.53 105.24,117.34 105.09,117.34 104.93,117.5 104.93,123.22 101.88,126.27 100.4,126.27 98.3,128.37 84.39,128.37 84.28,128.48 84.28,128.65 84.37,128.74 84.37,128.8 84.47,128.9 v2(84.54,128.9)
  BOTTOM w0.076: v2(105.61,117.77) 105.81,117.56 106.27,117.56 106.69,117.15 106.69,113.96 106.72,113.93 106.72,113.93 107.03,113.62 107.03,113.18 107.01,113.13 107.01,112.82 107.02,112.8 107.02,112.55 106.88,112.07 106.88,111.94 106.77,111.83 106.67,111.83 106.59,111.91 UC1.C45
EDP_TXP1_C: length 4.4
  TOP w0.104: v2(70.66,130.86) 70.84,130.68 70.84,130.21 CV5.2
  BOTTOM w0.104: v2(70.66,130.86) 70.86,131.06 70.86,131.2 70.73,131.33 69.74,131.33 69.39,131.68 69.39,132.01 69.25,132.16 JEDP1.37
EDRAM_OPIO_RCOMP: length 2.6
  TOP w0.127: v2(94.24,108.89) v1(94.79,109.44)
  TOP w0.381: RC90.1 93.43,109.42 93.96,108.89 v2(94.24,108.89)
  BOTTOM w0.254: v2(94.24,108.89) 94.44,108.7 UC1.H66
EMMC_RCOMP: length 6.7
  BOTTOM w0.127: RC4.1 137.96,94.74 v1(138.26,94.44)
  BOTTOM w0.203: UC1.AT1 132.93,94.56 133.5,95.13
  BOTTOM w0.381: 133.5,95.13 136.13,95.13 136.51,94.74 RC4.1
EN_0.6V: length 7.6
  TOP w0.112: PC222.1 73.8,74.8 v1(74.32,75.32)
  TOP w0.254: PC222.1 PR212.1 71.77,74.79 PR210.2 71.77,73.66 v2(71.33,73.23)
  BOTTOM w0.254: PU200.2 69.48,71.56 70.64,72.72 71.02,72.72 71.33,73.04 v2(71.33,73.23)
EN_1.0V_PRIM_COREP: length 8.3
  TOP w0.112: v2(162.91,125.44) 163.22,125.74 PC411.1 PR407.1 PR406.2
  BOTTOM w0.112: PU402.13 158.25,126.26 158.8,125.72 v1(159.23,125.72) 160.06,125.72 160.17,125.82 162.53,125.82 v2(162.91,125.44)
EN_1.2V: length 4.8
  TOP w0.112: v1(69.67,72.87) 70.03,73.23 v2(70.06,73.23)
  TOP w0.254: PR209.1 PC221.1 70,73.94 PR208.2 69.99,73.3 v2(70.06,73.23)
  BOTTOM w0.254: PU200.1 69.23,72.01 70.06,72.85 v2(70.06,73.23)
EN_1.8VALW: length 1.8
  BOTTOM w0.112: v1(176,65.26) 175.73,65 175.03,65 174.5,65.53
EN_1VS_VCCIO: length 4.9
  TOP w0.112: PR403.1 143.72,128.23 144.55,129.06 PR402.2
  TOP w0.254: v2(142.65,127.39) 142.84,127.58 PC402.1 PR403.1
  BOTTOM w0.112: v2(142.65,127.39) v1(143.2,126.83)
  BOTTOM w0.254: v2(142.65,127.39) 142.38,127.66 PU401.13
EN_2.5V: length 5.3
  TOP w0.112: PU503.5 151.51,58.66 151.71,58.46 151.71,57.14 PR514.1 PC513.1 PR513.2 v1(148.41,56.58)
EN_+1VALWP: length 2.6
  BOTTOM w0.254: PU301.1 156.53,85.64 156.11,86.07 PR302.1 PR312.1
EN_INVPWR: length 275.3
  TOP w0.107: 246.09,82.62 247.06,83.6 247.06,84.24 UE1.B2
  TOP w0.112: RE55.1 v2(246.09,81.54) 246.09,82.62 ; v2(40.03,122.18) 40.03,121.44 QV2.2 ; v1(242.07,76.83) v2(242.54,76.36)
  IN1 w0.119: v2(246.09,81.54) 245.9,81.54 243.25,78.9 243.25,77.47 242.54,76.76 v2(242.54,76.36)
  IN2 w0.124: v2(40.03,122.18) 40.03,122.89 41.76,124.61 46.38,124.61 47.61,125.85 48.86,125.85 50.14,124.57 60.86,124.57 62.84,126.55 67.84,126.55 68.43,127.14 74.62,127.14 74.88,126.88 79.93,126.88 83.43,130.38 103.91,130.38 104.68,131.15 108.6,131.15 109.46,130.28 117.52,130.28 118.75,131.51 124.08,131.51 124.71,130.87 124.71,130.46 125.12,130.06 126.31,130.06 126.95,130.69 130.01,130.69 130.91,131.6 134.47,131.6 135.79,132.92 141.77,132.92 141.98,132.7 145.13,132.7 147.97,129.87 155.79,129.87 156.42,129.23 156.42,125.54 161.59,120.37 161.59,119.62 162.22,118.99 162.22,110.22 166.85,105.58 166.85,90.59 169.22,88.23 169.22,85.67 171.58,83.3 171.58,80.67 181.51,70.74 185.1,70.74 186.82,69.02 206.17,69.02 207.44,67.75 222.1,67.75 222.76,68.41 225.83,68.41 226.45,69.03 227.94,69.03 231.05,72.13 232.8,72.13 234.11,73.45 235.04,73.45 235.94,74.34 235.94,75.3 236.61,75.97 236.61,76.62 237.1,77.12 238.44,77.12 239.15,76.4 242.5,76.4 v2(242.54,76.36)
EN_LCDPWR: length 8.9
  TOP w0.112: UV24.4 64.9,121.35 65.38,120.87 v1(66.22,120.87) 69.23,120.87 69.56,121.2 69.56,122.24 RV3.2 69.43,122.36 DV3.1
EN_PD_HV_1: length 79.2
  TOP w0.112: v2(33.29,88.64) 34.25,87.67 RT70.1 ; PR1210.1 33.29,53.3 33.87,52.72 37.11,52.72 38.7,51.13 PR1260.1 ; PQ1214.5 46.34,100.37 v2(46,100.02)
  TOP w0.203: PR1210.1 32.42,54.43 PR1250.2
  TOP w0.254: PR1211.1 35.33,62.56 35.14,62.37 v2(34.82,62.37) v1(34.25,61.8) PR1254.1 32.55,59.4 31.71,58.56 31.71,54.75 32.04,54.42 PR1250.2
  IN2 w0.124: v2(34.82,62.37) 35.08,62.37 35.39,62.69 35.39,63.11 36.17,63.88 36.17,65.56 34.29,67.44 34.29,72.11 35.74,73.56 35.74,79.31 37.13,80.71 37.13,85.42 v2(37.66,85.94) 37.17,86.43 37.17,88.67 36.52,89.32 33.97,89.32 v2(33.29,88.64)
  BOTTOM w0.112: v2(37.66,85.94) 37.51,86.09 37.51,89.19 40.28,91.96 41.17,91.96 42.19,92.98 42.19,97.91 43.12,98.84 45.76,98.84 46,99.08 v2(46,100.02)
EN_PD_HV_1#: length 1.8
  TOP w0.254: PQ1214.2 PQ1214.3 44.69,98.67 PR1253.2
EN_PD_HV_1_R: length 3.6
  TOP w0.076: UT5.C2 33.27,83.22 33.27,83.8 33.88,84.42 33.88,84.51
  TOP w0.112: 33.88,84.51 33.88,84.77 34.06,84.95 34.06,85.91 RT70.2
ENLDO_3V5V: length 66.5
  TOP w0.254: v2(146.84,77.96) 147.09,77.96 147.31,78.18 v2(152.53,78.18)
  IN3 w0.203: v2(179.91,59.12) 179.91,58.95 178.9,57.94 178.9,57.92 177.49,57.92 176.81,58.61 175.59,58.61 175.26,58.28 174.34,58.28 173.35,59.27 168.35,59.27 167.51,58.43 166.47,58.43 166.17,58.13 159.61,58.13 158.52,59.22 158.52,66.41 157.55,67.37 150.75,67.37 146.35,71.77 146.35,77.56 146.76,77.96 v2(146.84,77.96)
  BOTTOM w0.254: v2(179.91,59.12) 179.91,59.43 v1(180.32,59.85) 180.94,60.46 182.23,60.46 PR103.1 PR102.1 182.87,58.9 184.04,57.73 PU102.11 ; PU100.11 153.56,77.5 152.88,78.18 v2(152.53,78.18)
ENVDD_PCH: length 449.5
  TOP w0.107: UE1.L12 255.08,93.06 255.63,93.06 255.88,93.31 255.88,93.57 256.97,94.65 v2(256.97,94.82)
  TOP w0.112: v2(63.18,58.27) v1(63.89,57.56) 63.89,54.96 v2(63.73,54.79) ; v2(72.37,124.52) 71.55,124.52 DV3.3 70.79,125.28 69.38,125.28 68.21,124.12 64.01,124.12 v2(63.17,123.28)
  IN1 w0.119: v2(261.6,70.27) 262.12,70.79 263.23,70.79 263.55,70.47 263.55,69.86 263.94,69.47 263.94,67.26 261.59,64.91 259.76,64.91 259.36,65.31 252.4,65.31 250.73,63.65 248.73,63.65 245.01,59.93 245.01,58.66 242.97,56.62 242.97,52.05 v2(242.53,51.61)
  IN2 w0.124: v2(256.97,94.82) 257.83,94.82 257.96,94.94 258.31,94.94 260.47,92.78 261.39,92.78 262.4,91.77 262.4,89.04 263.98,87.46 263.98,86.36 264.32,86.02 264.32,82.51 264.99,81.84 264.99,74.47 261.6,71.07 v2(261.6,70.27) ; v2(63.73,54.79) 64.06,55.12 69.08,55.12 70.06,54.14 71.11,54.14 74.62,50.63 138.82,50.63 142.36,53.37 146.53,53.37 148.23,55.07 158.46,55.07 160.68,52.85 169.67,52.85 173.06,49.46 178.81,49.46 180.08,50.73 182.59,50.73 183.89,49.43 209.49,49.43 211,50.94 212.92,50.94 213.55,50.31 241.23,50.31 v2(242.53,51.61) ; v2(63.18,58.27) 64.33,59.41 64.33,65.43 62.2,67.55 62.2,74.64 72.77,85.2 72.77,88.73 73.1,89.06 73.1,103.24 72.44,103.9 71.42,103.9 70.51,104.81 70.51,110.91 70.18,111.24 62.41,111.24 60.41,113.23 60.41,115.45 61.74,116.79 61.74,119.57 63.17,120.99 v2(63.17,123.28) ; v2(125.07,104.81) 125.98,103.9 130.48,103.9 132.19,105.61 132.19,112.56 134.56,114.93 134.56,118.03 133.27,119.32 133.27,121.09 133.7,121.52 133.7,124.96 133.01,125.66 122.49,125.66 121.48,126.68 120.77,126.68 120.32,126.22 118.18,126.22 117.45,125.49 105,125.49 104.82,125.31 98.87,125.31 97.57,124.01 84.83,124.01 83.7,122.88 82.55,122.88 82.26,123.18 73.72,123.18 v2(72.37,124.52)
  BOTTOM w0.102: v2(125.07,104.81) 125.13,104.75 UC1.U13
EOPIO_RCOMP: length 3
  TOP w0.381: v2(95.31,108.87) 94.76,108.32 v1(94.16,108.32) 93.41,108.32 RC91.1
  BOTTOM w0.254: UC1.H65 95.6,108.87 v2(95.31,108.87)
ESPI_ALERT#: length 185.4
  TOP w0.107: UE1.H7 v2(252.68,88.26)
  TOP w0.112: v2(144.12,85.53) 144.22,85.43 RC21.1 144.22,83.63 v1(143.62,83.03)
  IN2 w0.124: v2(144.12,85.53) 144.85,84.8 144.85,83.49 148.21,80.13 148.21,72.38 150.14,70.45 150.47,70.45 151,69.92 159.53,69.92 163.05,66.4 172.69,66.4 175.79,63.3 178.15,63.3 178.68,63.82 180.59,63.82 181.47,62.95 182.53,62.95 182.83,62.65 202.29,62.65 204.43,60.51 218.18,60.51 219.05,61.39 225.96,61.39 226.84,60.51 234.92,60.51 235.24,60.83 236.76,60.83 237.66,59.93 239.17,59.93 242,62.76 243.62,62.76 244.66,63.79 244.66,65.3 247.87,68.51 248.97,68.51 250.67,70.21 253.16,70.21 253.41,70.47 256.21,70.47 256.51,70.17 257.17,70.17 257.4,70.39 v2(257.4,70.6)
  BOTTOM w0.076: 128.46,88.4 128.4,88.4 127.61,89.19 126.94,89.19 125.86,90.27 125.86,91.42 125.97,91.53 UC1.AY11
  BOTTOM w0.112: 128.46,88.4 131.05,85.81 133.87,85.81 134.64,85.04 135.66,85.04 136.36,84.34 139.03,84.34 139.59,84.91 143.49,84.91 v2(144.12,85.53) ; v2(252.68,88.26) 252.68,88.22 253.06,87.85 255.28,87.85 255.51,87.62 255.51,87.24 256.34,86.41 256.34,85.77 257.96,84.14 257.96,81.58 256.72,80.33 256.72,77.23 257.46,76.48 257.46,75.74 256.76,75.03 256.76,73.37 257.66,72.47 257.66,70.85 v2(257.4,70.6)
ESPI_CLK: length 28.6
  BOTTOM w0.076: UC1.AW9 127.34,92.36 127.18,91.84 127.18,91.73 127.07,91.42 127.07,91.28 127.13,91.06 127.13,90.94 127.08,90.83 127.08,90.46 127.34,90.21 127.94,90.21 128.42,89.72 128.83,89.72
  BOTTOM w0.102: 128.83,89.72 130.15,88.4 130.43,88.4
  BOTTOM w0.112: 130.43,88.4 131.76,87.07 134.14,87.07 135.16,86.05 136.28,86.05 137.11,85.23 137.67,85.23 137.9,85.46 137.9,85.89 138.44,86.43 143.59,86.43 147.11,89.95 v1(147.89,89.95) 148.63,89.95 RC16.1
ESPI_CLK_5105: length 172.6
  TOP w0.107: UE1.G7 v2(251.08,88.26)
  TOP w0.112: v2(150.52,89.75) 149.99,89.75 v1(149.64,89.41) ; RE350.1 248.84,74.93 248.84,74.31 249.36,73.79 v2(251.28,73.79)
  IN3 w0.135: v2(150.52,89.75) 150.5,89.75 149.59,88.83 149.59,88.38 148.73,87.52 148.73,85.89 147.32,84.47 147.32,72.03 151.07,68.28 159.26,68.28 162.9,64.64 170.72,64.64 173.47,61.89 177.9,61.89 178.61,61.18 181.73,61.18 182.98,59.93 200.51,59.93 203.67,56.77 208.53,56.77 209.22,57.45 215.84,57.45 216.31,57.93 217.75,57.93 218.39,57.29 225.16,57.29 225.68,56.76 225.68,55.2 226.58,54.3 231.41,54.3 232.82,52.89 239.63,52.89 240.15,53.41 243.01,53.41 v2(243.44,53.83)
  BOTTOM w0.112: v2(150.52,89.75) 150.39,89.75 150,89.36 CC316.1 RC16.2 ; v2(243.44,53.83) 242.95,54.32 JESPI.10 242.95,55.62 243.45,56.12 244.08,56.12 246.07,58.11 246.07,59.93 247.5,61.35 247.5,62.88 249.45,64.83 249.45,68.15 251.28,69.98 v2(251.28,73.79) 252.03,74.53 252.03,80.46 251.2,81.28 251.2,84.39 251.48,84.67 251.48,87.86 v2(251.08,88.26)
ESPI_CS#: length 192.7
  TOP w0.107: UE1.H6 v2(252.68,87.46)
  IN3 w0.135: v2(244.27,55.59) 243.05,54.37 235.42,54.37 234.97,54.82 226.8,54.82 226.2,55.41 226.2,56.98 225.37,57.8 218.86,57.8 218.23,58.44 216.1,58.44 215.8,58.14 209.11,58.14 208.25,57.28 205.1,57.28 203.82,58.56 202.69,58.56 200.8,60.45 183.22,60.45 181.98,61.7 178.88,61.7 178.15,62.42 173.67,62.42 170.93,65.16 163.11,65.16 159.47,68.8 151.3,68.8 147.85,72.24 147.85,84.27 149.25,85.68 149.25,87.31 v2(150.52,88.58)
  BOTTOM w0.076: UC1.BA12 125.69,91.63 125.69,90.18 126.88,88.99 127.51,88.99 129.13,87.36
  BOTTOM w0.112: 129.13,87.36 130.91,85.58 133.72,85.58 134.52,84.78 135.53,84.78 136.23,84.08 139.15,84.08 139.66,84.59 143.92,84.59 144.65,85.33 v1(144.65,85.86) 144.65,86.64 146.47,88.45 147.86,88.45 148.02,88.61 150.44,88.61 150.47,88.58 v2(150.52,88.58) ; JESPI.7 244.45,55.41 v2(244.27,55.59) 246.84,58.15 246.84,59.93 248,61.1 248,62.67 250.49,65.16 250.49,68.19 252.07,69.77 252.07,72.95 252.83,73.71 252.83,76.84 253.11,77.12 253.11,78.5 252.6,79.01 252.6,80.36 252.75,80.52 252.75,84.31 253.08,84.64 253.08,87.06 v2(252.68,87.46)
ESPI_IO0: length 158.9
  TOP w0.107: UE1.K5 v2(254.28,86.66)
  TOP w0.112: v2(150.51,85.6) v1(149.77,85.6)
  IN3 w0.135: v2(246.15,56.16) 245.13,57.18 243.33,57.18 241.57,55.42 235.77,55.42 233.27,57.92 228.74,57.92 227.75,58.91 220.14,58.91 219.15,59.9 215.76,59.9 215.18,59.31 206.7,59.31 206.09,59.92 202.79,59.92 201.31,61.4 183.7,61.4 180.24,64.86 176.3,64.86 176.14,65.01 172.41,65.01 171.32,66.1 163.5,66.1 159.86,69.74 151.69,69.74 148.79,72.64 148.79,83.88 v2(150.51,85.6)
  BOTTOM w0.112: v2(254.28,86.66) 254.7,86.24 255.28,86.24 255.59,85.93 255.59,83.87 255.31,83.59 255.31,77.57 254.82,77.08 254.82,73.22 253.02,71.42 253.02,69.04 251.78,67.8 251.78,65.84 248.51,62.57 248.51,60.89 247.98,60.36 247.98,57.5 247.07,56.59 246.58,56.59 v2(246.15,56.16) 246.45,55.86 JESPI.3 ; v2(150.51,85.6) 150.39,85.48 RC366.2
ESPI_IO0_R: length 30.7
  BOTTOM w0.076: 127.1,87.74 124.95,89.89 124.95,90.39 124.83,90.52 124.83,90.79 124.88,90.91 124.88,91.05 124.82,91.28 124.82,91.4 124.89,91.61 124.99,91.72 125.1,91.83 UC1.AY13
  BOTTOM w0.112: 127.1,87.74 127.33,87.74 130.43,84.64 133.13,84.64 134.01,83.77 134.96,83.77 136.27,82.46 136.83,82.46 137.44,83.07 139.65,83.07 140.16,83.58 144.7,83.58 146.8,85.67 v1(147.81,85.67) 148.73,85.67 RC366.1
ESPI_IO1: length 159.7
  TOP w0.107: UE1.L4 v2(255.08,85.86)
  TOP w0.112: v2(150.51,87.13) v1(149.75,87.13)
  IN3 w0.135: v2(245.55,56.16) 245.41,56.31 243.19,56.31 241.78,54.89 235.56,54.89 235.17,55.29 229.49,55.29 228.14,56.63 228.14,57.14 227.81,57.47 226.48,57.47 225.67,58.28 219.06,58.28 218.42,58.91 215.9,58.91 215.61,58.62 206.32,58.62 205.64,59.3 202.75,59.3 201.12,60.93 183.46,60.93 182.22,62.17 179.14,62.17 178.36,62.95 173.8,62.95 171.12,65.63 163.31,65.63 159.67,69.27 151.49,69.27 148.32,72.44 148.32,84.08 149.81,85.57 149.81,86.43 v2(150.51,87.13)
  BOTTOM w0.112: v2(255.08,85.86) 254.69,85.46 254.69,84.05 255.09,83.65 255.09,81.33 253.67,79.9 253.67,78.07 254.61,77.13 254.61,73.36 252.79,71.55 252.79,69.17 251.57,67.94 251.57,65.93 248.26,62.62 248.26,61.02 247.06,59.83 247.06,57.67 v2(245.55,56.16) 245.95,55.76 JESPI.4 ; v2(150.51,87.13) 149.96,87.13 RC367.2
ESPI_IO1_R: length 29.9
  BOTTOM w0.076: UC1.BA13 125.1,91.13 125.36,90.87 125.36,90 126.83,88.53 127.29,88.53 128.65,87.17
  BOTTOM w0.112: RC367.1 148.64,87.54 v1(147.85,87.54) 147.06,87.54 146.04,86.51 146.04,85.72 144.4,84.08 139.91,84.08 139.41,83.58 135.98,83.58 135.28,84.28 134.26,84.28 133.41,85.13 130.69,85.13 128.65,87.17
ESPI_IO2: length 157.4
  TOP w0.107: UE1.G6 v2(251.08,87.46)
  TOP w0.112: v2(150.51,86.26) v1(151.28,86.26) ; v2(245.45,55.56) 245.45,55.58 244.29,56.74 v2(244.01,56.74)
  IN3 w0.135: v2(244.01,56.74) 243.25,56.74 241.67,55.16 235.67,55.16 233.16,57.66 228.63,57.66 227.62,58.67 220.04,58.67 219.1,59.61 215.88,59.61 215.35,59.08 206.6,59.08 205.99,59.69 202.69,59.69 201.21,61.16 183.58,61.16 181.43,63.31 173.78,63.31 171.22,65.86 163.4,65.86 159.76,69.5 151.59,69.5 148.55,72.54 148.55,83.98 150.04,85.47 150.04,85.79 v2(150.51,86.26)
  BOTTOM w0.112: RC368.2 149.94,86.26 v2(150.51,86.26) ; v2(251.08,87.46) 250.68,87.06 250.68,83.11 250.71,83.08 250.71,81.08 251.53,80.25 251.53,74.77 250.77,74.01 250.77,70.17 248.51,67.91 248.51,64.63 246.99,63.1 246.99,61.56 245.54,60.11 245.54,58.27 v2(244.01,56.74) ; JESPI.5 v2(245.45,55.56)
ESPI_IO2_R: length 28.8
  BOTTOM w0.076: 128.45,87.01 127.15,88.3 126.81,88.3 125.19,89.92 125.19,90.4 125.1,90.5 UC1.BB13
  BOTTOM w0.112: 128.45,87.01 130.55,84.9 133.26,84.9 134.14,84.02 135.15,84.02 135.85,83.32 139.53,83.32 140.04,83.83 144.65,83.83 146.49,85.67 v1(146.49,86.19) 146.67,86.37 RC368.1
ESPI_IO3: length 165.3
  TOP w0.107: UE1.L5 v2(255.08,86.66)
  TOP w0.112: v2(150.51,87.71) v1(151.24,87.71)
  IN3 w0.135: v2(244.85,55.59) 244.85,55.62 244.43,56.04 243.3,56.04 241.89,54.63 235.49,54.63 235.07,55.05 229.39,55.05 228.55,55.89 226.82,55.89 226.43,56.28 226.43,57.08 225.47,58.04 218.96,58.04 218.32,58.68 216,58.68 215.7,58.38 206.23,58.38 205.55,59.06 202.65,59.06 201.02,60.69 183.34,60.69 182.1,61.93 179,61.93 178.26,62.67 173.75,62.67 171.03,65.39 163.21,65.39 159.57,69.03 151.39,69.03 148.08,72.34 148.08,84.17 149.53,85.62 149.53,86.78 150.46,87.71 v2(150.51,87.71)
  BOTTOM w0.112: v2(255.08,86.66) 255.25,86.66 255.8,86.1 255.8,83.78 255.52,83.5 255.52,77.48 255.05,77.01 255.05,73.12 253.27,71.35 253.27,68.96 251.99,67.68 251.99,65.75 248.92,62.67 248.92,57.34 248.31,56.73 248.31,54.25 247.86,53.81 245.21,53.81 244.95,54.07 JESPI.6 244.95,55.49 v2(244.85,55.59) ; v2(150.51,87.71) 150.27,87.71 RC369.2
ESPI_IO3_R: length 30.9
  BOTTOM w0.076: 128.88,87.27 127.39,88.76 126.86,88.76 125.53,90.09 125.53,91.23 125.36,91.39 125.36,91.82 125.67,92.12 UC1.AY12
  BOTTOM w0.112: 128.88,87.27 130.8,85.35 133.56,85.35 134.39,84.53 135.41,84.53 136.1,83.83 139.28,83.83 139.79,84.34 144.04,84.34 144.99,85.28 144.99,86.48 v1(146.24,87.73) 146.66,88.15 RC369.1
ESPI_RESET#: length 177.7
  TOP w0.107: UE1.K6 v2(254.28,87.46)
  IN2 w0.124: v2(150.52,89.16) 151.28,88.4 153.21,88.4 153.83,89.02 159.97,89.02 160.62,88.37 163.83,88.37 165.42,86.79 165.42,84.03 167.64,81.81 167.64,78.59 168.61,77.61 168.61,72.57 169.87,71.31 174.85,71.31 179.12,67.04 183.3,67.04 185.25,65.09 203.23,65.09 204.58,63.74 227.12,63.74 228.67,65.28 229.55,65.28 230.23,64.61 236.2,64.61 238,66.41 240.26,66.41 240.83,66.98 240.83,67.41 242.87,69.45 243.33,69.45 243.92,70.04 245.1,70.04 245.78,70.72 249.2,70.72 249.82,71.34 252.65,71.34 252.9,71.6 255.63,71.6 256.03,71.99 257.02,71.99 v2(257.22,72.2)
  BOTTOM w0.076: UC1.BA11 126.02,91.07 126.02,90.36 126.91,89.47 127.66,89.47 128.45,88.68 128.53,88.68
  BOTTOM w0.112: 128.53,88.68 131.17,86.04 134.02,86.04 134.77,85.29 135.79,85.29 136.49,84.59 137.82,84.59 138.23,85 138.23,85.7 138.71,86.18 143.75,86.18 146.42,88.85 v1(147.2,88.85) 150.2,88.85 v2(150.52,89.16) ; v2(254.28,87.46) 254.28,87.44 254.66,87.07 255.38,87.07 256.13,86.32 256.13,85.68 257.75,84.05 257.75,81.67 256.26,80.18 256.26,76.9 256.06,76.69 256.06,75.49 256.54,75.01 256.54,72.89 v2(257.22,72.2)
EXPANDER_ALERT#: length 1.5
  TOP w0.112: T267.1 271.25,92.21 271.25,92.22 UE2.7
EXPANDER_GPU_SMCLK: length 18.1
  TOP w0.107: v2(256.83,85.86) 255.88,85.86 UE1.M4
  TOP w0.112: v2(259.17,85.19) 259.29,85.06 RE525.1 ; UE2.19 v2(265.39,92.22)
  IN3 w0.135: v2(265.39,92.22) 265.63,91.98 266.07,91.98 266.39,91.65 266.39,90.84 263.39,87.83 260.78,87.83 260.15,87.19 260.15,85.74 259.75,85.34 259.32,85.34 v2(259.17,85.19) 258.98,85.38 257.31,85.38 v2(256.83,85.86)
EXPANDER_GPU_SMDAT: length 18.6
  TOP w0.107: v2(255.88,88.25) 255.88,88.26 UE1.M7
  TOP w0.112: v2(265.43,91.4) 265.75,91.72 UE2.20 ; RE524.1 259.35,85.95 v2(259.17,85.77)
  IN3 w0.135: v2(265.43,91.4) 265.75,91.72 265.96,91.72 266.13,91.55 266.13,90.95 263.28,88.09 260.67,88.09 259.88,87.3 259.88,85.84 259.64,85.6 259.34,85.6 v2(259.17,85.77) 259.04,85.64 257.85,85.64 256.72,86.78 256.72,87.41 v2(255.88,88.25)
FAN1_PWM: length 53.3
  TOP w0.107: UE1.L10 v2(255.08,91.46)
  TOP w0.112: v2(238.57,122.06) 237.56,121.05 v1(237.56,117.1) 237.56,116.61 240.04,114.13 249.72,114.13 249.92,114.34 251.74,114.34 252.49,113.58 253.75,113.58 254.57,112.76 v2(254.57,112.45)
  IN3 w0.135: v2(254.57,112.45) 254.57,111.72 254.19,111.34 254.19,107.71 252.4,105.92 252.4,99.08 251.36,98.04 251.36,96.98 252.46,95.87 253.64,95.87 255.5,94.02 255.5,91.87 v2(255.08,91.46)
  BOTTOM w0.112: RE48.2 v2(238.57,122.06) 238.15,122.06 237.5,121.41 JFAN1.2
FAN1_TACH: length 52.7
  TOP w0.102: v3(239.11,120.91) 238.82,120.91 v2(238.57,121.17)
  TOP w0.107: UE1.E3 v2(249.48,85.06)
  IN1 w0.119: v2(238.57,121.17) 237.18,119.78 237.18,116.34 238.99,114.54 238.99,111.8 237.69,110.51 237.69,104.13 238.1,103.71 238.1,93.74 238.92,92.93 238.92,88.29 238.76,88.12 v2(238.76,87.56)
  IN2 w0.124: v2(249.48,85.06) 249.36,85.06 248.89,84.59 246.84,84.59 246.58,84.85 246.58,85.38 245.36,86.6 242.88,86.6 242.29,87.19 239.12,87.19 v2(238.76,87.56)
  BOTTOM w0.112: JFAN1.3 237.46,120.16 238.47,121.17 v2(238.57,121.17) RE51.2
FB_1.8VALW: length 4.5
  BOTTOM w0.112: v1(171.49,70.95) PR506.1
  BOTTOM w0.254: PU501.6 172.13,68.78 PR501.2 PC503.2 172.89,69.55 PR506.1
FB_+1VALWP: length 4.3
  BOTTOM w0.112: PR308.2 v1(152.47,86.17)
  BOTTOM w0.254: PU301.4 155.18,85.13 155.22,85.16 PR311.1 PR306.2 PR308.2
FB_IA: length 4.4
  TOP w0.203: PR650.1 PR645.2 55.37,93.66 PR648.2 54.37,93.66 54,94.03 54,94.45 53.68,94.77 PU602.17
FB_VSA: length 4.9
  TOP w0.203: PU602.25 v1(50.33,97.87) 50.93,98.46 v2(51,98.46)
  BOTTOM w0.203: v2(51,98.46) 50.76,98.7 PR646.1
  BOTTOM w0.254: PR649.1 51.62,99.38 PR646.1 PR652.1
FCCM_GT: length 7.6
  TOP w0.203: v2(53.54,92.09) 53.44,92.09 53.16,92.37 PU602.11
  BOTTOM w0.254: v2(53.54,92.09) 54.25,92.09 v1(56.74,94.58) 57.68,95.51 PR671.2
FCCM_IA: length 21.6
  TOP w0.203: v2(52.78,97.93) 52.78,97.83 51.93,96.98 PU602.21
  IN1 w0.254: v2(56.49,113.02) 56.27,113.02 54.96,111.72 54.96,102.45 53.59,101.08 53.59,98.74 v2(52.78,97.93)
  BOTTOM w0.254: PR659.2 59.07,111.85 57.89,113.02 v1(57.48,113.02) v2(56.49,113.02)
FCCM_VSA: length 32.8
  TOP w0.112: v2(59.46,116.09) 59.12,116.09 v1(58.93,116.28)
  TOP w0.203: PU602.29 48.73,97.68 47.83,98.59 v2(47.75,98.59)
  TOP w0.254: PR679.2 v2(59.46,116.09)
  IN1 w0.254: v2(47.75,98.59) 47.52,98.82 47.52,101.21 47.18,101.55 47.18,102.44 48.56,103.82 48.56,106.94 47.5,108.01 47.5,113.47 49.34,115.31 54.6,115.31 55.37,116.09 v2(59.46,116.09)
FIVR_EN: length 1.8
  BOTTOM w0.112: RC217.1 RC219.1 RC218.1
FIVR_EN_R: length 4.5
  BOTTOM w0.112: RC132.1 RC217.2 RC126.2 90.24,127.16 90.24,128.03 90.31,128.09 JXDP1.45
GPIO126: length 5.4
  TOP w0.107: UE1.E12 249.48,93.06 249.48,94.82 v1(248.81,95.5) 248.81,96.55 248.14,97.22 RE5.1
GPP_B23: length 13.7
  TOP w0.112: v2(128.35,96.69) 128.57,96.91 130.69,96.91 132.02,95.58 133.95,95.58 134.08,95.72 v1(136.12,95.72) 137.45,95.72 138.23,96.49 138.23,96.76 138.52,97.06 138.9,97.06 139.22,97.37 RC317.1
  BOTTOM w0.102: v2(128.35,96.69) 128.71,97.05 UC1.AM7
GPP_C5: length 10.5
  BOTTOM w0.076: UC1.W1 132.79,103.29 135.33,103.29 135.51,103.47 136.85,103.47
  BOTTOM w0.112: 136.85,103.47 137.67,103.47 138.18,103.98 v1(138.76,103.98) 141.12,103.98 RC25.1
GPP_C8: length 5.1
  BOTTOM w0.076: UC1.AB1 132.45,101.81 133.88,101.81 134.01,101.94 135.55,101.94
  BOTTOM w0.112: RC405.1 136.38,101.34 v1(136.26,101.47) 135.79,101.94 135.55,101.94
GPP_E23: length 1.5
  TOP w0.112: T120.1 125.78,106.61 v2(126.11,106.94)
  BOTTOM w0.102: UC1.N12 v2(126.11,106.94)
GPU_B+:
  vias: v2(62.51,89.16) v2(63.14,89.16) v2(63.78,89.16) v2(64.41,89.16) v2(65.05,89.16) v3(61.87,89.48)
GT1P: length 3.7
  TOP w0.112: v2(65.3,99.64) v1(65.3,100.19)
  TOP w0.254: v2(65.3,99.64) PR674.2
  BOTTOM w0.254: PL612.3 64.54,98.88 v2(65.3,99.64)
GT_SNUB1: length 1.7
  TOP w0.112: v1(60.87,95.85) 61.33,95.39 PR676.2
GT_SW1:
  vias: v2(62,96.78) v2(62.64,96.78) v3(61.37,95.77)
H_CATERR#: length 9.2
  BOTTOM w0.076: 95.91,116.79 96.44,116.25 96.44,115.26 96.94,114.76 96.94,113.71 97.11,113.54 97.11,113.18 97.07,113.08 97.07,112.89 97.11,112.8 97.11,112.55 96.97,112.07 96.97,111.96 96.89,111.69 UC1.D63
  BOTTOM w0.102: 95.91,116.79 95.91,117.89 v1(96,117.98) 96.16,118.14 96.16,119.63 RC79.1
H_CPU_SVIDALRT#: length 8
  BOTTOM w0.076: 95.08,116.77 95.6,116.25 95.6,115.25 96.44,114.41 96.44,113.56 96.36,113.48 96.36,112.98 UC1.B63
  BOTTOM w0.112: RC153.1 93.38,118.69 93.38,118.06 93.59,117.85 94,117.85 v1(94.86,116.99) 95.08,116.77
H_CPUPWRGD: length 12.7
  BOTTOM w0.112: RC77.2 85.84,120.17 85.84,119.35 CC300.1 v1(88.44,115.8) 90.13,114.11 92.41,114.11 92.84,113.67 93.19,113.67 UC1.A68
H_CPUPWRGD_R: length 1.1
  BOTTOM w0.112: T9.1 84.72,121.56 RC77.1
H_PROCHOT#: length 401.3
  TOP w0.112: v2(166.22,81.75) 166.11,81.75 165.73,82.13 165.73,88.4 164.03,90.1 161.47,90.1 160.79,89.42 153.6,89.42 152.32,88.14 147.37,88.14 147.04,87.82 139.83,87.82 139.17,88.49 v2(137.83,88.49) ; v2(227.42,84.97) 227.95,85.51 227.95,86.45 228.6,87.1 229.53,87.1 233.7,91.27 233.7,92.16 235.15,93.61 236.18,93.61 236.6,93.2 237.05,93.2 237.3,93.46 239.08,93.46 239.86,94.23 242.21,94.23 v2(242.72,94.74) ; RE288.2 252.07,96.67 251.8,96.94 v2(251.8,97.27) ; PR926.1 v2(50.56,55.01)
  IN1 w0.119: v2(50.56,55.01) 51.16,55.61 52.14,55.61 53.54,54.21 56.64,54.21 59.28,56.86 61.03,56.86 63.05,58.88 63.88,58.88 65.04,57.72 69.47,57.72 69.72,57.48 71.41,57.48 72.04,58.11 72.04,62.17 71.47,62.74 71.47,65.81 72.77,67.11 72.77,70.03 73.24,70.5 73.24,71.64 v2(72.92,71.96) ; v2(137.83,88.49) 139.22,87.1 139.22,85.05 139.88,84.39 142.18,84.39 143.82,82.74 143.82,79.75 143.38,79.31 143.38,78.37 143.82,77.93 143.82,76.78 142.18,75.13 87.5,75.13 81.27,81.37 73.3,81.37 v2(72.46,82.21) 71.64,81.38 61.24,81.38 58.87,83.75 56.23,83.75 v2(53.75,86.24) ; v2(45.9,92.67) 44.68,92.67 44.16,92.15 43.12,92.15 42.02,93.24 42.02,97.49 43.11,98.58 43.11,102.42 42.66,102.86 42.66,107.7 43.12,108.16 43.12,113.88 48.28,119.04 50.31,119.04 52.4,121.14 66.26,121.14 66.69,120.7 70.69,120.7 71.1,120.29 71.1,120.26 71.24,120.12 79.59,120.12 80.1,119.61 86.38,119.61 87.14,120.37 v2(88.23,120.37) ; v2(214.84,73.55) 215.36,73.04 216.53,73.04 216.6,73.1 222.15,73.1 224.41,75.36 224.41,80.85 226.97,83.41 226.97,84.53 v2(227.42,84.97)
  IN2 w0.124: v2(242.72,94.74) 242.72,95.21 244.37,96.86 246.63,96.86 247.5,97.74 251.34,97.74 v2(251.8,97.27)
  IN3 w0.135: v2(72.92,71.96) 72.92,74.88 72.46,75.33 v2(72.46,82.21)
  BOTTOM w0.112: PC605.2 PR678.1 46.09,92.67 v2(45.9,92.67) 45.87,92.64 45.87,89.77 48.19,87.45 v1(51.41,87.45) 52.54,87.45 v2(53.75,86.24) ; v2(166.22,81.75) 166.29,81.82 173.2,81.82 185.3,69.72 211.01,69.72 214.84,73.55 v2(214.84,73.55) ; v2(88.23,120.37) RC84.1 CC310.1 RC83.1
H_PROCHOT#_R: length 12.3
  BOTTOM w0.076: 94.74,115.78 94.74,114.95 95.4,114.29 95.4,113.58 95.28,113.47 95.28,113.21 95.34,113.09 95.34,112.94 95.28,112.75 95.28,112.58 95.37,112.32 UC1.C65
  BOTTOM w0.112: RC84.2 88.23,118.57 v1(89.05,117.74) 90.36,116.43 92.49,116.43 92.68,116.62 93.9,116.62 94.74,115.78
H_PROCHOT#_R1: length 2.3
  TOP w0.107: UE1.H13 v1(252.28,94.85) 252.28,95.72 RE288.1
H_THERMTRIP#: length 340.7
  TOP w0.112: v2(138.58,51.85) 137.98,51.26 109.24,51.26 108.85,51.65 ; v2(264.63,100.67) 264.54,100.67 QE4.3 ; 108.85,51.65 108.52,51.32 75.84,51.32 v2(73.56,53.6) ; 108.85,51.65 RD14.2
  IN1 w0.119: v2(138.58,51.85) 140.89,51.85 142.31,53.27 145.96,53.27 148.33,55.64 160.08,55.64 161.88,53.84 177.87,53.84 179.71,52.01 183.02,52.01 185.56,49.47 238.72,49.47 242.54,53.3 242.54,58.06 248.55,64.07 250.56,64.07 252.28,65.8 259.64,65.8 260.09,65.34 261.37,65.34 263.42,67.39 v2(263.42,69.05)
  IN3 w0.135: v2(79.53,110.69) 79.73,110.89 79.73,111.69 79.15,112.28 79.15,114.82 80.92,116.6 87.78,116.6 89.31,118.12 89.31,118.45 90.31,119.45 93.5,119.45 v2(95.55,121.5) ; v2(76.41,85.93) 76.19,85.7 76.19,73.01 74.96,71.77 74.96,59.69 74.07,58.8 74.07,54.12 v2(73.56,53.6)
  BOTTOM w0.076: UC1.C63 96.86,112.32 96.94,112.58 96.94,112.75 96.89,112.94 96.89,113.09 96.94,113.21 96.94,113.47 96.78,113.64 96.78,114.64 96.26,115.15 96.26,116.14
  BOTTOM w0.102: 96.26,116.14 95.66,116.75 95.66,118.13 95.91,118.39 95.91,119.28 CC312.1
  BOTTOM w0.112: CC312.1 RC80.1 95.41,121.36 v2(95.55,121.5) ; v2(263.42,69.05) 262.15,70.32 262.15,72.73 265.1,75.68 265.1,77.79 268.13,80.82 268.13,84.97 268.71,85.55 268.71,93.46 266.65,95.51 266.65,96.47 264.51,98.61 264.51,100.56 v2(264.63,100.67) ; v2(79.53,110.69) 79.51,110.68 79.51,93.81 77.82,92.12 v1(77.82,90.97) 77.82,87.97 76.41,86.56 v2(76.41,85.93)
H_VCCST_PWRGD_XDP: length 112.7
  TOP w0.112: v2(123.75,81.14) 124.31,81.14 RC124.2 ; v2(89.64,122.26) 89.64,123.79 91.85,125.99 91.85,128.2 92.11,128.47 v2(92.11,128.79)
  IN1 w0.119: v2(75.57,87.09) 79.41,87.09 88.58,77.93 120.77,77.93 123.75,80.91 v2(123.75,81.14)
  IN3 w0.135: v2(89.64,122.26) 89.64,121.88 88.7,120.95 87.19,120.95 84.91,118.67 78.22,118.67 v2(78.19,118.69)
  BOTTOM w0.112: RC123.2 90,121.89 v2(89.64,122.26) ; v2(78.19,118.69) 78.19,117.55 78.77,116.97 v1(78.77,116.85) 78.94,116.68 78.94,115.12 78.61,114.79 78.61,94.09 76.99,92.47 76.99,88.85 75.57,87.43 v2(75.57,87.09) ; v2(92.11,128.79) 92.09,128.76 CC307.1 92.54,128.48 92.54,128.98 92.11,129.41 JXDP1.39
HDA_BIT_CLK: length 12.1
  TOP w0.112: v2(120.38,82.1) 119.09,80.81 RC93.2
  BOTTOM w0.076: UC1.AY22 120.25,91.83 120.15,91.72 120.05,91.61 119.98,91.4 119.98,91.09 119.83,90.94 119.83,90.36 120.11,90.09 120.11,87.99
  BOTTOM w0.102: 120.11,87.99 v1(120.39,87.29) 120.46,87.1 120.46,82.19 v2(120.38,82.1)
HDA_BIT_CLK_R: length 160.6
  TOP w0.112: v2(257.96,64.58) 257.96,65.26 257.76,65.47 RA17.1 257.53,65.29 UA1.6 ; RC93.1 119.57,79.39 119.57,78.56 CC27.1 119.09,76.87 v1(120.49,75.47) 121.03,74.93 140.51,74.93 147.61,67.83 162.71,67.83 165.06,70.18 172.17,70.18 173.52,68.82 178.57,68.82 181.1,66.29 184.04,66.29 187.53,64.83 227.18,64.83 228.38,66.03 229.85,66.03 230.33,65.56 234.66,65.56 235.06,65.96 235.06,67.13 236.32,68.39 239.03,68.39 240.4,69.76 243.99,69.76 244.73,70.5 254.65,70.5 255.01,70.13 v2(255.01,69.81)
  BOTTOM w0.112: v2(257.96,64.58) 257.96,66.13 256.11,67.98 256.11,70.01 255.88,70.24 255.45,70.24 v2(255.01,69.81)
HDA_RST#: length 15.7
  TOP w0.112: v2(121.5,87.13) 121.53,87.1 121.53,82.78 v1(121.64,82.67) 121.74,82.58 121.74,79.12 CC331.1 RC95.2
  BOTTOM w0.076: v2(121.5,87.13) 120.95,87.97 120.95,89.28 120.67,89.56 120.67,90.34 120.54,90.59 120.54,92.18 UC1.AW22
HDA_RST#_R: length 149.3
  TOP w0.112: RA50.1 260.88,70.7 260.15,71.44 259.13,71.44 257.86,70.17 256.49,70.17 255.17,71.49 249.26,71.49 249.26,71.49 243.94,71.49 243.23,70.78 240.05,70.78 238.66,69.39 235.95,69.39 234.03,67.47 231.8,67.47 231.52,67.75 227.61,67.75 226.4,66.54 188.25,66.54 184.69,68.08 182.01,68.08 178.9,71.19 164.65,71.19 162.33,68.87 148.03,68.87 140.89,76.01 124.68,76.01 v1(124.56,76.13) 123.91,76.78 RC95.1
HDA_SDIN0: length 164.4
  TOP w0.112: v2(121.33,88.94) 121.59,88.94 121.87,88.66 121.87,88.14 121.06,87.32 121.06,86.75 121.32,86.49 121.32,82.56 121.5,82.38 121.5,80.53 CC332.1 120.85,76.87 121.97,75.76 140.76,75.76 147.9,68.62 162.43,68.62 164.77,70.95 178.65,70.95 v1(180.42,69.18) 181.84,67.77 184.65,67.77 188.14,66.31 226.5,66.31 227.71,67.51 231.42,67.51 231.7,67.23 234.13,67.23 236.05,69.15 238.76,69.15 240.13,70.52 243.38,70.52 244.11,71.25 255.07,71.25 256.13,70.19 256.13,69.3 255.93,69.1 255.93,66.94 256.49,66.38 RA9.1
  BOTTOM w0.076: UC1.BA21 120.82,90.51 121.03,90.31 121.03,89.9 121.33,89.6 v2(121.33,88.94)
