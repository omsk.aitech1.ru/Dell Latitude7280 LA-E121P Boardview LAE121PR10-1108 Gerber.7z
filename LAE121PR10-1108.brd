# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D18: length 48.1
  IN3 w0.117: v2(92.7,84.29) 92.63,84.22 92.63,82.64 92.16,82.17 90.23,80.24 90.23,66.08 90.94,65.37 90.94,64.61 91.15,64.4 91.15,57.11 91.47,56.79 91.47,54.06 91.21,53.81 89.81,53.81 89.56,54.06 89.56,54.8 89.8,55.04 v2(90.02,55.04)
  BOTTOM w0.076: v2(92.7,84.29) 92.71,84.29 93.74,85.32 93.74,87.29 94.19,87.73 95.33,87.73 97.3,89.7 97.3,91.34 97.08,91.56 97.07,91.7 97.07,91.83 97.09,91.95 97.09,92.12 97.08,92.13 97.08,92.13 96.77,92.44 UC1.AW63
  BOTTOM w0.102: v2(90.02,55.04) 90.39,55.04 90.48,54.95 JDIMM1.58
DDR_A_D19: length 47.3
  IN3 w0.117: v2(92.7,87.34) 92.24,86.88 92.24,86.21 91.62,85.58 91.62,83.04 90.43,81.85 89.54,81.85 89.23,81.54 89.23,72.1 89.11,71.99 88.84,71.99 88.72,71.87 88.72,71.64 88.84,71.52 89.11,71.52 89.23,71.4 89.23,71.17 89.11,71.05 88.84,71.05 88.72,70.94 88.72,70.7 88.84,70.58 89.11,70.58 89.23,70.47 89.23,70.23 89.11,70.12 88.84,70.12 88.72,70 88.72,69.77 88.84,69.65 89.11,69.65 89.23,69.53 89.23,69.31 89.11,69.2 88.84,69.2 88.72,69.08 88.72,68.85 88.84,68.73 89.11,68.73 89.23,68.61 89.23,68.38 89.11,68.26 88.84,68.26 88.72,68.15 88.72,66.16 89.66,65.21 89.68,65.21 89.94,64.96 89.94,64.12 90.15,63.91 90.15,62.67 90.03,62.55 90.03,62.55 89.91,62.43 89.91,62.2 90.03,62.08 90.03,62.08 90.15,61.96 90.15,61.73 90.03,61.61 90.03,61.61 89.91,61.5 89.91,61.26 90.03,61.15 90.03,61.15 90.15,61.03 90.15,60.8 90.03,60.68 90.03,60.68 89.91,60.56 89.91,60.33 90.09,60.15 90.09,58.92 v2(90.02,58.85)
  BOTTOM w0.076: UC1.AY63 96.67,91.89 96.67,91.63 96.59,91.41 96.59,91.28 96.66,91.05 96.66,90.91 96.6,90.79 96.6,90.55 96.78,90.37 96.78,89.96 95.05,88.23 93.73,88.23 92.84,87.34 v2(92.7,87.34)
  BOTTOM w0.112: JDIMM1.59 90.73,61.13 90.61,61.02 90.57,61.02 90.21,60.66 90.21,60.5 90.32,60.39 90.54,60.39 90.65,60.28 90.65,59.97 90.54,59.85 90.3,59.85 90.18,59.74 90.18,59.43 90.3,59.32 90.56,59.32 90.68,59.21 90.68,58.91 90.56,58.8 90.26,58.8 90.21,58.85 v2(90.02,58.85)
DDR_A_D20: length 46.7
  IN3 w0.117: v2(91.18,87.13) 90.78,87.13 89,85.36 87.09,83.45 87.09,78.22 86.98,78.11 86.7,78.11 86.58,77.99 86.58,77.75 86.7,77.64 86.98,77.64 87.09,77.52 87.09,77.29 86.98,77.17 86.7,77.17 86.58,77.05 86.58,76.82 86.7,76.7 86.98,76.7 87.09,76.59 87.09,76.35 86.98,76.24 86.7,76.24 86.58,76.12 86.58,75.89 86.7,75.77 86.83,75.77 86.94,75.65 86.94,75.34 86.58,74.98 86.58,65.26 87.77,64.07 87.77,61.37 87.59,61.19 87.59,57.99 v2(87.17,57.58)
  BOTTOM w0.076: UC1.BA65 95.54,91.19 95.4,91.05 95.4,91.04 95.39,91.04 95.29,90.82 95.29,89.88 94.67,89.27 92.53,89.27 91.54,88.27 91.54,87.49 v2(91.18,87.13)
  BOTTOM w0.112: JDIMM1.49 88.23,61.06 88.44,60.85 88.44,60.31 87.59,59.46 87.59,57.99 v2(87.17,57.58)
DDR_A_D21: length 47.1
  IN3 w0.117: v2(87.17,58.85) 87.17,62.09 87.44,62.35 87.44,63.94 86.25,65.13 86.25,78.44 86.37,78.55 86.64,78.55 86.76,78.67 86.76,78.91 86.64,79.02 86.37,79.02 86.25,79.14 86.25,79.37 86.37,79.49 86.64,79.49 86.76,79.61 86.76,79.84 86.64,79.96 86.37,79.96 86.25,80.07 86.25,80.31 86.37,80.42 86.64,80.42 86.76,80.54 86.76,80.77 86.64,80.89 86.37,80.89 86.25,81.01 86.25,81.24 86.37,81.36 86.62,81.36 86.76,81.5 86.76,81.83 86.64,81.96 86.64,82.28 86.76,82.4 86.76,83.59 88.87,85.69 90.94,87.77 v2(91.16,87.77)
  BOTTOM w0.076: v2(91.16,87.77) 91.16,88.17 92.44,89.46 94.6,89.46 95.12,89.98 95.12,90.85 95.15,90.92 95.15,92.14 95.23,92.21 95.47,92.21 95.54,92.14 UC1.AY65
  BOTTOM w0.112: v2(87.17,58.85) 87.17,59.54 87.06,59.65 86.93,59.65 86.82,59.76 86.82,60.12 86.93,60.23 87.9,60.23 88.01,60.35 88.01,60.66 87.9,60.77 87.33,60.77 87.23,60.87 JDIMM1.45
DDR_A_D22: length 47
  IN3 w0.117: v2(92.7,85.51) 92.28,85.09 92.28,82.76 89.89,80.37 89.89,65.94 90.61,65.23 90.61,64.4 90.81,64.19 90.81,56.97 91.13,56.65 91.13,55.5 91.02,55.38 90.64,55.38 90.52,55.5 90.52,56.09 90.31,56.31 v2(90.02,56.31)
  BOTTOM w0.076: v2(92.7,85.51) 93.35,86.16 93.35,87.15 94.1,87.9 95.23,87.9 97.13,89.8 97.13,90.86 96.87,91.12 UC1.BA63
  BOTTOM w0.112: JDIMM1.62 91.48,55.31 91.37,55.41 90.85,55.41 90.73,55.53 90.73,55.7 90.85,55.82 91.26,55.82 91.36,55.92 91.36,56.19 91.24,56.31 v2(90.02,56.31)
DDR_A_D23: length 45.6
  IN3 w0.117: v2(90.02,57.58) 90.02,57.49 90.18,57.33 90.37,57.33 90.48,57.45 90.48,64.05 90.27,64.26 90.27,65.09 89.56,65.81 89.56,66.29 89.44,66.41 89.17,66.41 89.05,66.53 89.05,66.76 89.17,66.88 89.44,66.88 89.56,67 89.56,67.23 89.44,67.35 89.17,67.35 89.05,67.46 89.05,67.7 89.17,67.81 89.44,67.81 89.56,67.93 89.56,81.4 89.68,81.52 90.57,81.52 91.95,82.9 91.95,85.44 92.62,86.12 v2(92.7,86.12)
  BOTTOM w0.076: v2(92.7,86.12) 92.81,86 92.96,86 93.19,86.23 93.19,87.45 93.8,88.06 95.13,88.06 96.95,89.88 96.95,90.61 UC1.BB63
  BOTTOM w0.112: JDIMM1.63 91.73,61.11 91.17,60.55 91.17,58.68 90.07,57.58 v2(90.02,57.58)
DDR_A_D24: length 44.3
  IN3 w0.117: v2(94.32,86.04) 93.9,85.62 93.9,85.29 93.59,84.97 93.59,82.24 91.18,79.84 91.18,66.48 91.89,65.77 91.9,65.77 91.9,65.01 92.1,64.8 92.1,61.97 92.22,61.85 92.81,61.85 92.93,61.73 92.93,61.5 92.81,61.38 92.22,61.38 92.1,61.27 92.1,61.05 92.22,60.93 92.81,60.93 92.93,60.82 92.93,60.58 92.81,60.46 92.22,60.46 92.1,60.35 92.1,60.13 92.23,60.01 92.74,60.01 92.9,59.85 92.9,59.63 92.72,59.44 v2(92.19,59.44)
  BOTTOM w0.076: v2(94.32,86.04) 94.65,86.04 95.03,86.42 95.03,86.92 97.63,89.52 97.63,90.85 97.9,91.11 UC1.BA61
  BOTTOM w0.112: v2(92.19,59.44) 92.41,59.22 94.09,59.22 94.33,59.47 94.33,60.41 93.73,61.02 JDIMM1.71
DDR_A_D25: length 45.4
  IN3 w0.117: v2(92.2,56.32) 92.09,56.43 92.09,57.05 91.77,57.37 91.77,64.66 91.56,64.87 91.56,65.63 90.85,66.34 90.85,79.98 93.25,82.38 93.25,85.12 93.56,85.43 93.56,85.75 93.91,86.1 93.91,86.93 v2(94.32,87.34)
  BOTTOM w0.076: UC1.AW61 98,92.51 97.68,92.19 97.68,91.95 97.7,91.83 97.7,91.61 97.7,91.61 97.7,91.6 97.47,91.37 97.47,89.61 95.19,87.34 v2(94.32,87.34)
  BOTTOM w0.112: v2(92.2,56.32) 92.2,56.57 92.41,56.78 92.69,56.78 93.48,55.99 93.48,55.62 93.59,55.51 93.88,55.51 93.99,55.4 93.99,55.18 93.88,55.06 93.59,55.06 93.48,54.95 JDIMM1.70
DDR_A_D26: length 44
  IN3 w0.117: v2(96.27,57.61) 96.49,57.39 96.94,57.39 97.12,57.57 97.12,62.43 97.24,62.55 97.34,62.55 97.46,62.66 97.46,62.9 97.34,63.01 97.18,63.01 97.06,63.13 97.06,63.36 97.18,63.48 97.52,63.48 97.64,63.6 97.64,63.83 97.52,63.95 97.18,63.95 97.06,64.07 97.06,64.41 95.05,66.42 95.05,67.08 94.36,67.77 94.36,78.93 96.87,81.45 96.87,83.7 96.3,84.28 v2(96.25,84.28)
  BOTTOM w0.076: UC1.BB59 99.32,90.58 99.32,89.88 99.08,89.64 99.08,89.04 v1(97.95,87.91) 97.17,87.13 97.17,85.2 v2(96.25,84.28)
  BOTTOM w0.112: v2(96.27,57.61) 95.4,58.48 95.4,60.15 95.73,60.47 JDIMM1.79
DDR_A_D27: length 45.8
  IN3 w0.117: v2(96.25,85.58) 96.25,85.57 95.82,85.14 95.82,81.27 93.36,78.81 93.36,67.35 94.05,66.67 94.05,65.9 95.09,64.87 95.09,56.38 95.21,56.27 95.64,56.27 95.76,56.15 95.76,55.91 95.64,55.8 95.21,55.8 95.09,55.68 95.09,54.76 95.21,54.64 95.85,54.64 v2(96.27,55.07)
  BOTTOM w0.076: UC1.AW59 98.52,92.64 98.33,92.45 98.33,92.17 98.37,92.14 98.37,91.92 98.29,91.82 98.29,91.57 98.34,91.44 98.34,91.21 98.33,91.2 98.33,91.2 98.33,91.2 98.29,91.11 98.29,90.91 98.33,90.82 98.33,90.46 98.13,90.26 98.13,89.28 95.86,87.01 95.86,85.97 v2(96.25,85.58)
  BOTTOM w0.112: v2(96.27,55.07) 95.98,54.77 JDIMM1.80
DDR_A_D28: length 44
  IN3 w0.117: v2(94.32,85.36) 94.32,85.22 93.92,84.83 93.92,82.1 91.54,79.72 91.54,66.6 92.23,65.91 92.23,65.14 92.74,64.63 92.74,64.47 92.62,64.35 92.55,64.35 92.44,64.23 92.44,64 92.55,63.88 92.62,63.88 92.74,63.77 92.74,63.48 92.62,63.36 92.55,63.36 92.44,63.25 92.44,63.05 92.66,62.83 92.66,62.66 92.44,62.44 92.44,62.27 92.52,62.18 93.15,62.18 93.26,62.07 93.26,59.36 93.15,59.24 92.99,59.24 92.65,58.91 92.65,58.19 92.53,58.07 92.36,58.07 v2(92.23,58.2)
  BOTTOM w0.076: v2(94.32,85.36) 94.65,85.02 95.34,85.02 95.42,85.1 95.42,87.08 97.8,89.45 97.8,90.58 UC1.BB61
  BOTTOM w0.112: JDIMM1.67 92.73,60.7 92.94,60.49 92.94,59.97 92.83,59.86 91.92,59.86 91.77,59.71 91.77,58.65 v2(92.23,58.2)
DDR_A_D29: length 44.8
  IN3 w0.117: v2(92.19,55.1) 93.58,55.1 93.7,55.22 93.7,55.77 92.99,56.48 92.99,58.77 93.1,58.89 93.47,58.89 93.6,59.01 93.6,62.6 93.47,62.73 93.19,62.73 93.07,62.84 93.07,64.78 92.56,65.29 92.56,66.05 91.87,66.74 91.87,79.59 94.33,82.05 v2(94.33,84.05)
  BOTTOM w0.076: UC1.AY61 98.1,91.89 98.1,91.62 98.13,91.52 98.13,91.52 98.16,91.44 98.16,91.23 98.13,91.14 98.13,90.88 98.16,90.79 98.16,90.53 97.96,90.33 97.96,89.38 95.59,87.01 95.59,84.23 95.41,84.05 v2(94.33,84.05)
  BOTTOM w0.102: v2(92.19,55.1) 92.48,54.81 JDIMM1.66
DDR_A_D30: length 45.2
  IN3 w0.117: v2(96.27,58.88) 96.61,58.88 96.73,58.99 96.73,61.24 96.61,61.36 95.87,61.36 95.75,61.47 95.75,61.71 95.87,61.82 96.61,61.82 96.73,61.94 96.73,62.17 96.61,62.29 96.21,62.29 96.1,62.41 96.1,62.64 96.21,62.76 96.61,62.76 96.73,62.88 96.73,63.29 96.61,63.4 96.51,63.4 96.39,63.52 96.39,63.75 96.51,63.87 96.61,63.87 96.73,63.99 96.73,64.27 94.72,66.28 94.72,66.94 94.03,67.63 94.03,78.89 96.67,81.53 96.67,83.21 v2(96.25,83.63)
  BOTTOM w0.076: v2(96.25,83.63) 97.08,83.63 97.36,83.91 97.36,86.93 99.25,88.81 99.25,89.57 99.49,89.81 99.49,90.78 99.43,90.93 UC1.BA59
  BOTTOM w0.112: v2(96.27,58.88) 96.27,59.33 96.57,59.63 96.57,60.22 96.69,60.34 97.58,60.34 97.7,60.46 97.7,60.63 97.58,60.74 96.83,60.74 96.72,60.85 96.72,61.9 JDIMM1.83
DDR_A_D31: length 45.8
  IN3 w0.117: v2(96.25,82.34) 96.46,82.13 96.46,81.62 93.7,78.85 93.7,67.49 94.39,66.8 94.39,66.14 95.42,65.11 95.42,61.02 95.54,60.91 96.17,60.91 96.29,60.79 96.29,60.56 96.17,60.44 95.54,60.44 95.42,60.32 95.42,60.09 95.54,59.97 96.17,59.97 96.29,59.86 96.29,59.62 96.17,59.51 95.54,59.51 95.42,59.39 95.42,56.73 95.55,56.6 95.78,56.6 96.04,56.34 v2(96.27,56.34)
  BOTTOM w0.076: v2(96.25,82.34) 96.53,82.34 97.56,83.37 97.56,86.85 99.41,88.71 99.41,89.5 99.65,89.74 99.65,90.82 99.62,90.89 99.49,91.32 99.49,91.52 99.22,91.78 UC1.AY59
  BOTTOM w0.112: v2(96.27,56.34) 96.98,55.63 JDIMM1.84
DDR_A_D32: length 48.1
  IN3 w0.076: 112.59,78.6 110.98,80.21 v2(110.98,82.13)
  IN3 w0.117: 112.59,78.6 113.05,78.14 113.05,73.45 118.16,68.34 120.27,68.34 120.46,68.16 120.46,67.79 120.62,67.63 120.99,67.63 121.29,67.33 121.29,66.93 121.41,66.82 121.8,66.82 121.92,66.7 121.92,66.47 121.8,66.35 121.41,66.35 121.29,66.23 121.29,66 121.41,65.88 122.41,65.88 122.53,65.76 122.53,65.52 122.41,65.41 121.41,65.41 121.29,65.29 121.29,58.53 121.41,58.41 121.66,58.41 v2(122.04,58.78)
  BOTTOM w0.076: 109.59,84.62 109.59,89.36 109.92,89.68 109.92,90.35 109.83,90.43 109.83,90.83 109.9,90.96 109.9,90.98 110,91.23 110,91.52 110.27,91.78 UC1.AY39
  BOTTOM w0.112: JDIMM1.169 120.23,61.9 120.23,60.99 121.41,59.8 121.41,59.41 v2(122.04,58.78) ; 109.59,84.62 109.59,83.51 v2(110.98,82.13)
DDR_A_D33: length 46
  IN3 w0.076: v2(110.98,88.09) 110.45,87.56 110.45,80.16 112.39,78.22 112.39,77.35
  IN3 w0.117: v2(122.04,56.24) 120.62,57.66 120.62,66.34 120.05,66.91 119.22,66.91 118.48,67.65 117.91,67.65 112.39,73.17 112.39,77.35
  BOTTOM w0.076: UC1.AW39 110.92,92.64 111.21,92.35 111.21,91.85 111.19,91.56 111.17,91.5 111.17,91.18 111.19,91.11 111.2,90.89 111.17,90.78 111.17,90.44 111.36,90.25 111.36,88.48 v2(110.98,88.09)
  BOTTOM w0.112: JDIMM1.174 121.48,55.68 v2(122.04,56.24)
DDR_A_D34: length 47.7
  IN3 w0.076: v2(110.98,87.44) 111.37,87.83 111.97,87.83 112.06,87.74 112.06,80.61 113.8,78.87
  IN3 w0.117: v2(124.78,60.05) 124.78,60.82 124.98,61.01 124.98,61.3 124.8,61.47 124.32,61.47 124.2,61.59 124.2,61.85 124.32,61.96 124.86,61.96 124.98,62.08 124.98,62.37 124.86,62.48 124.47,62.48 124.35,62.6 124.35,64.68 124.47,64.8 124.87,64.8 124.98,64.91 124.98,65.15 124.87,65.27 124.47,65.27 124.35,65.38 124.35,65.62 124.47,65.73 125.01,65.73 125.13,65.85 125.13,66.08 125.01,66.2 124.47,66.2 124.35,66.32 124.35,66.85 121.04,70.16 118.97,70.16 114.88,74.26 114.88,77.51 114.76,77.63 114.57,77.63 114.42,77.78 114.42,77.92 114.57,78.07 114.71,78.07 114.83,78.19 114.83,78.37 114.48,78.73 113.94,78.73 113.8,78.87
  BOTTOM w0.076: UC1.AY37 111.39,91.89 111.39,91.63 111.34,91.48 111.34,91.24 111.38,91.08 111.38,90.96 111.34,90.76 111.34,90.51 111.53,90.32 111.53,88.31 111.35,88.14 111.35,87.82 v2(110.98,87.44)
  BOTTOM w0.112: JDIMM1.187 124.73,60.73 124.61,60.62 124.38,60.62 124.27,60.5 124.27,60.17 124.38,60.05 v2(124.78,60.05)
DDR_A_D35: length 48.8
  IN3 w0.076: 112.25,81.01 112.23,81.01 112.23,84.1 112.32,84.19 v2(112.75,84.19)
  IN3 w0.117: 112.25,81.01 112.93,80.33 113.39,80.33 113.88,79.83 113.88,79.67 113.71,79.5 113.71,79.34 113.88,79.17 114.05,79.17 114.21,79.34 114.38,79.34 115.21,78.51 115.21,74.41 119.11,70.51 121.18,70.51 125.46,66.23 125.46,65.96 125.58,65.85 125.79,65.85 125.9,65.73 125.9,65.44 125.73,65.26 125.43,65.26 125.32,65.15 125.32,64.85 125.31,64.84 125.31,64.41 125.16,64.26 124.79,64.26 124.69,64.16 124.69,62.95 124.82,62.81 125.18,62.81 125.31,62.69 125.31,61.94 125.44,61.81 125.55,61.81 125.7,61.66 125.7,61.26 125.56,61.12 125.37,61.12 125.31,61.05 125.31,60.87 125.12,60.68 125.12,60.3 125.31,60.11 125.31,58.9 125.19,58.78 v2(124.78,58.78)
  BOTTOM w0.076: v2(112.75,84.19) 112.02,84.92 112.02,90.32 112.02,91.34 111.8,91.56 111.8,92.11 111.49,92.42 UC1.AW37
  BOTTOM w0.112: v2(124.78,58.78) 123.94,59.63 123.94,60.54 123.73,60.76 JDIMM1.183
DDR_A_D36: length 46.1
  IN3 w0.076: 111.38,80.15 111.25,80.27 111.25,80.78 111.43,80.96 111.43,81.34 111.38,81.39 111.25,81.39 111.17,81.47 111.17,81.65 111.25,81.72 111.35,81.72 111.43,81.8 111.43,84.11 111.35,84.19 v2(110.98,84.19)
  IN3 w0.117: v2(122.04,60.05) 121.77,60.05 121.62,60.2 121.62,62.68 121.78,62.84 122.75,62.84 122.86,62.96 122.86,63.55 122.75,63.67 121.76,63.67 121.65,63.78 121.65,64.02 121.76,64.14 122.75,64.14 122.86,64.25 122.86,64.5 122.76,64.6 121.77,64.6 121.62,64.76 121.62,64.96 121.74,65.07 122.75,65.07 122.86,65.19 122.86,66.22 122.7,66.38 122.35,66.38 122.25,66.48 122.25,66.84 120.41,68.67 118.33,68.67 113.38,73.62 113.38,78.14 111.38,80.15
  BOTTOM w0.076: v2(110.98,84.19) 110.06,85.11 110.06,89.24 110.25,89.43 110.25,90.66 UC1.BB39
  BOTTOM w0.112: JDIMM1.173 121.23,61.9 121.23,60.87 v2(122.04,60.05)
DDR_A_D37: length 47
  IN3 w0.076: 112.72,77.35 112.72,78.17 110.61,80.28 110.61,83.18 v2(110.98,83.54)
  IN3 w0.117: v2(122.04,57.51) 121.24,57.51 120.96,57.8 120.96,67.1 120.76,67.3 120.24,67.3 120.13,67.41 120.13,67.87 120.01,67.98 119.8,67.98 119.69,67.87 119.69,67.36 119.57,67.24 119.36,67.24 119.22,67.39 119.22,67.87 119.1,67.98 118.04,67.98 112.72,73.31 112.72,77.35
  BOTTOM w0.076: v2(110.98,83.54) 109.83,84.69 v4(109.83,88.45) 109.83,89.29 110.08,89.54 110.08,90.42 110,90.5 110,90.79 110.12,91.04 110.12,91.04 110.13,91.05 110.27,91.19 UC1.BA39
  BOTTOM w0.112: JDIMM1.170 120.48,55.95 v2(122.04,57.51)
DDR_A_D38: length 47.8
  IN3 w0.076: 112.9,80.76 112.39,81.27 112.39,82.4 v2(112.75,82.76)
  IN3 w0.117: 112.9,80.76 113.25,80.76 115.54,78.47 115.54,74.56 119.25,70.85 121.31,70.85 126.24,65.92 126.24,65.3 125.64,64.7 125.64,62.19 126.04,61.8 126.04,61.13 125.64,60.73 125.64,57.33 125.53,57.21 125.09,57.21 v2(124.78,57.51)
  BOTTOM w0.076: UC1.BA37 111.59,91.12 111.86,90.86 111.86,90.39 111.86,90.39 111.86,88.14 111.82,88.1 v4(111.82,87.81) 111.82,87.46 111.86,87.43 111.86,83.66 v2(112.75,82.76)
  BOTTOM w0.112: v2(124.78,57.51) 123.47,56.21 123.47,53.7 JDIMM1.182
DDR_A_D39: length 46.6
  IN3 w0.076: 115.39,78.91 113.1,81.2 113.1,81.7 v2(112.75,82.05)
  IN3 w0.117: 115.39,78.91 115.87,78.42 115.87,74.74 119.39,71.22 121.43,71.22 126.57,66.08 126.57,65.16 125.98,64.57 125.98,62.33 126.37,61.93 126.37,60.99 125.98,60.59 125.98,56.16 125.73,55.92 125.11,55.92 v2(124.78,56.24)
  BOTTOM w0.076: UC1.BB37 111.59,90.49 111.69,90.39 111.69,88.23 111.64,88.18 111.64,87.35 111.69,87.3 111.69,83.11 112.39,82.42
  BOTTOM w0.112: v2(124.78,56.24) 124.47,55.94 124.47,53.7 JDIMM1.186 ; 112.39,82.42 v2(112.75,82.05)
DDR_A_D40: length 48.6
  IN3 w0.076: v2(112.75,86.14) 113.14,86.52 113.36,86.52 113.43,86.45 113.43,81.41 116.43,78.41 116.44,78.41
  IN3 w0.117: v2(127.37,58.78) 127.05,58.78 126.93,58.9 126.93,60.2 127.33,60.59 127.33,62.35 126.93,62.74 126.93,64.17 127.72,64.96 127.72,66.29 121.82,72.2 119.79,72.2 116.83,75.15 116.83,78.02 116.44,78.41
  BOTTOM w0.076: v2(112.75,86.14) 112.75,85.98 112.99,85.75 113.23,85.75 113.31,85.83 113.31,88.34 112.68,88.97 112.68,90.01 112.89,90.22 112.89,90.79 112.85,90.88 112.85,90.89 112.85,91.14 112.89,91.23 112.89,91.44 112.86,91.52 112.82,91.62 112.82,91.89 UC1.AY35
  BOTTOM w0.112: v2(127.37,58.78) 126.11,58.78 125.73,59.17 JDIMM1.191
DDR_A_D41: length 50.1
  IN3 w0.076: v2(112.75,84.84) 113.27,84.33 113.27,81.29 116.34,78.22
  IN3 w0.117: 116.34,78.22 116.5,78.06 116.5,75 119.65,71.84 121.69,71.84 127.19,66.34 127.19,64.9 126.6,64.31 126.6,62.59 126.99,62.19 126.99,60.73 126.6,60.34 126.6,58.48 126.72,58.36 126.81,58.36 126.92,58.24 126.92,58.01 126.81,57.89 126.72,57.89 126.6,57.78 126.6,57.18 126.72,57.06 126.97,57.06 127.37,57.46 v2(127.37,57.51)
  BOTTOM w0.076: UC1.AW35 112.72,92.42 112.4,92.1 112.4,91.58 112.19,91.37 112.19,90.25 112.19,90.25 112.19,85.41 v2(112.75,84.84)
  BOTTOM w0.112: v2(127.37,57.51) 126.61,57.51 125.48,56.37 JDIMM1.190
DDR_A_D42: length 49.2
  IN3 w0.076: 119.32,77.35 119.32,77.74 115.02,82.04 115.02,83.45 v2(114.58,83.89)
  IN3 w0.117: v2(130.62,58.78) 130.21,59.2 130.21,64.28 130.33,64.4 130.79,64.4 130.9,64.51 130.9,64.75 130.79,64.86 130.33,64.86 130.21,64.98 130.21,65.21 130.33,65.33 130.79,65.33 130.9,65.45 130.9,65.68 130.79,65.8 130.33,65.8 130.21,65.92 130.21,66.15 130.33,66.27 130.79,66.27 130.9,66.38 130.9,66.62 130.79,66.73 130.33,66.73 130.21,66.85 130.21,67.43 122.83,74.81 120.77,74.81 119.32,76.26 119.32,77.26 119.32,77.26 119.32,77.35
  BOTTOM w0.076: v2(114.58,83.89) 115.04,84.36 115.04,88.32 114.5,88.86 114.5,89.66 114.2,89.96 114.2,90.28 114.25,90.34 114.25,90.34 114.38,90.46 114.38,90.83 114.27,91.06 114.22,91.17 114.22,91.51 113.95,91.78 UC1.AY33
  BOTTOM w0.112: JDIMM1.203 128.73,60.48 130.42,58.78 v2(130.62,58.78)
DDR_A_D43: length 48.4
  IN3 w0.076: v2(114.58,83.26) 114.58,82.22 118.99,77.81 118.99,77.35
  IN3 w0.117: 118.99,77.35 118.99,77.24 118.99,76.12 120.63,74.48 122.69,74.48 129.88,67.29 129.88,58.8 130.13,58.55 130.13,56.73 v2(130.62,56.24)
  BOTTOM w0.076: UC1.AW33 113.3,92.64 113.09,92.43 113.09,91.92 113.02,91.82 113.02,91.57 113.06,91.44 113.06,91.21 113.06,91.2 113.05,91.2 113.05,91.2 113.02,91.11 113.02,90.91 113.05,90.82 113.05,90.82 113.05,90.15 112.96,90.05 112.96,88.93 113.48,88.41 113.48,84.36 v2(114.58,83.26)
  BOTTOM w0.112: v2(130.62,56.24) 129.98,54.83 129.98,53.7 JDIMM1.208
DDR_A_D44: length 47.5
  IN3 w0.076: 113.94,81.21 113.6,81.54 113.6,87.02 113.51,87.11 113.07,87.11 v2(112.75,86.79)
  IN3 w0.117: 113.94,81.21 114.14,81 114.31,81 114.37,81.06 114.54,81.06 114.7,80.9 114.7,80.73 114.64,80.67 114.64,80.5 114.81,80.34 114.97,80.34 115.03,80.4 115.2,80.4 115.37,80.24 115.37,80.07 115.3,80.01 115.3,79.84 115.47,79.68 115.63,79.68 115.7,79.74 115.86,79.74 116.03,79.57 116.03,79.41 115.96,79.35 115.96,79.18 116.13,79.01 116.29,79.01 116.36,79.08 116.52,79.08 116.69,78.91 116.69,78.75 116.62,78.68 116.62,78.52 117.16,77.98 117.16,75.3 119.89,72.58 121.94,72.58 128.05,66.47 128.05,64.61 127.65,64.2 127.44,64.2 127.27,64.03 127.27,62.88 127.38,62.76 127.94,62.76 128.05,62.65 128.05,62.4 127.94,62.28 127.78,62.28 127.66,62.16 127.66,61.93 127.78,61.81 127.94,61.81 128.05,61.7 128.05,61.42 127.94,61.3 127.78,61.3 127.66,61.18 127.66,60.95 127.78,60.83 127.94,60.83 128.05,60.71 128.05,60.17 127.94,60.05 v2(127.37,60.05)
  BOTTOM w0.076: UC1.BB35 112.52,90.58 112.52,90.12 112.52,90.12 112.52,88.9 113.15,88.27 113.15,86.91 113.03,86.79 v2(112.75,86.79)
  BOTTOM w0.112: v2(127.37,60.05) 126.16,60.05 126.05,60.17 126.05,60.53 126.19,60.66 126.59,60.66 126.73,60.8 JDIMM1.195
DDR_A_D45: length 48
  IN3 w0.076: 117.35,78.51 113.76,82.1 113.76,87.69 113.36,88.09 v2(112.75,88.09)
  IN3 w0.117: 117.35,78.51 117.5,78.37 117.5,75.48 120.04,72.93 122.1,72.93 128.39,66.65 128.39,58.5 128.2,58.31 128.2,56 127.96,55.76 127.5,55.76 127.37,55.89 v2(127.37,56.24)
  BOTTOM w0.076: v2(112.75,88.09) 112.35,88.49 112.35,90.18 112.35,90.19 112.35,90.85 112.62,91.11 UC1.BA35
  BOTTOM w0.112: v2(127.37,56.24) 127.37,55.62 126.47,54.72 126.48,54.72 JDIMM1.194
DDR_A_D46: length 47.7
  IN3 w0.076: v2(114.58,87.7) 115.54,86.75 115.54,82.06 119.99,77.6 119.99,77.35
  IN3 w0.117: 119.99,77.35 119.99,76.56 121.06,75.5 123.11,75.5 131.7,66.91 131.7,62.8 132.01,62.49 132.01,60.51 131.04,59.53 131.04,57.93 v2(130.62,57.51)
  BOTTOM w0.076: v2(114.58,87.7) 114.32,87.96 114.32,89.6 114.04,89.89 114.04,90.35 114.21,90.53 114.21,90.79 114.1,91.04 114.09,91.04 114.09,91.05 113.95,91.19 UC1.BA33
  BOTTOM w0.112: v2(130.62,57.51) 129.64,56.53 129.64,55.79 128.98,55.12 128.98,53.7 JDIMM1.204
DDR_A_D47: length 46.5
  IN3 w0.076: v2(114.58,87.07) 115.27,86.38 115.27,82.05 119.65,77.66 119.65,77.35
  IN3 w0.117: v2(130.62,60.05) 130.62,60.74 130.74,60.86 131,60.86 131.11,60.74 131.11,60.55 131.23,60.43 131.46,60.43 131.68,60.65 131.68,61.21 131.56,61.33 130.74,61.33 130.62,61.45 130.62,61.68 130.74,61.8 131.56,61.8 131.68,61.91 131.68,62.12 131.54,62.26 130.74,62.26 130.62,62.38 130.62,62.6 130.75,62.72 131.27,62.72 131.37,62.83 131.37,66.76 122.97,75.16 120.91,75.16 119.66,76.41 119.66,77.28 119.65,77.28 119.65,77.35
  BOTTOM w0.076: v2(114.58,87.07) 114.12,87.53 114.12,89.57 113.87,89.82 113.87,90.46 113.95,90.54 UC1.BB33
  BOTTOM w0.112: JDIMM1.207 129.73,60.65 130.32,60.05 v2(130.62,60.05)
DDR_A_D48: length 50.8
  IN3 w0.076: v2(116.42,82.43) 116.42,81.96 119.23,79.15 119.57,79.15 121.28,77.43 121.28,77.35
  IN3 w0.117: v2(132.81,59.32) 133.18,59.32 133.3,59.44 133.3,60.12 133.42,60.24 133.75,60.24 133.9,60.39 133.9,60.59 133.79,60.7 133.42,60.7 133.3,60.82 133.3,61.06 133.42,61.17 133.88,61.17 134.01,61.31 134.01,61.52 133.9,61.64 133.42,61.64 133.3,61.76 133.3,61.99 133.42,62.11 133.8,62.11 133.93,62.24 133.93,62.46 133.82,62.58 133.6,62.58 133.49,62.69 133.49,63.81 133.38,63.92 133.11,63.92 132.99,64.03 132.99,64.32 133.11,64.44 133.39,64.44 133.53,64.57 133.53,64.78 133.41,64.9 133.11,64.9 132.99,65.02 132.99,66.71 133.22,66.94 133.22,67.27 123.65,76.85 121.73,76.85 121.28,77.29 121.28,77.35
  BOTTOM w0.076: v2(116.42,82.43) 115.3,83.55 115.3,89.09 114.99,89.41 114.99,90.29 114.82,90.46 114.82,90.82 114.98,91.23 114.98,91.52 115.25,91.78 UC1.AY31
  BOTTOM w0.112: JDIMM1.215 131.73,60.88 131.84,60.77 132.11,60.77 132.22,60.66 132.22,60.4 132.1,60.29 131.64,60.29 131.53,60.17 131.53,59.8 132.01,59.32 v2(132.81,59.32)
DDR_A_D49: length 50.7
  IN3 w0.076: v2(116.42,88.15) 115.74,87.47 115.74,82.11 119.2,78.65 119.5,78.65 120.62,77.53 120.62,77.35
  IN3 w0.117: v2(132.81,56.78) 131.85,56.78 131.66,56.97 131.66,59.28 132.64,60.25 132.64,62.75 132.33,63.06 132.33,67.19 132.15,67.36 132.14,67.36 123.37,76.13 121.33,76.13 120.62,76.85 120.62,77.35
  BOTTOM w0.076: UC1.AW31 115.94,92.64 116.16,92.42 116.16,91.85 116.18,91.83 116.18,91.57 116.12,91.42 116.12,91.28 116.19,91.06 116.19,90.94 116.15,90.86 116.14,90.83 116.14,90.3 116.44,90.01 116.44,88.17 v2(116.42,88.15)
  BOTTOM w0.112: JDIMM1.212 130.98,53.7 130.98,54.94 v2(132.81,56.78)
DDR_A_D50: length 50
  IN3 w0.076: 122.07,78.7 121.49,78.7 119.84,80.35 119.28,80.35 117.42,82.21 117.42,86.51 v2(116.42,87.51)
  IN3 w0.117: 122.07,78.7 124.41,78.7 135.35,67.75 135.35,64.46 135.7,64.11 135.7,63.27 135.84,63.13 135.84,55.94 v2(136.26,55.51)
  BOTTOM w0.076: UC1.AY29 116.37,91.89 116.37,91.63 116.3,91.41 116.3,91.28 116.36,91.05 116.36,90.91 116.31,90.79 116.31,90.37 116.6,90.08 116.6,88.6 116.79,88.42 116.79,88.01 116.42,87.64 v2(116.42,87.51)
  BOTTOM w0.112: v2(136.26,55.51) 135.49,55.51 134.98,54.99 134.98,53.7 JDIMM1.228
DDR_A_D51: length 51.1
  IN3 w0.076: v2(118.01,84.34) 117.63,83.96 117.63,82.26 119.28,80.61 119.91,80.61 121.28,79.23 121.69,79.23 121.87,79.06 122.07,79.06
  IN3 w0.117: v2(136.26,59.32) 136.41,59.46 136.41,63.4 136.29,63.52 136.21,63.52 136.09,63.63 136.09,63.87 136.21,63.98 136.29,63.98 136.41,64.1 136.41,64.34 136.29,64.45 135.83,64.45 135.69,64.6 135.69,64.8 135.8,64.92 136.29,64.92 136.41,65.04 136.41,65.27 136.29,65.39 135.83,65.39 135.69,65.53 135.69,65.74 135.8,65.86 136.29,65.86 136.41,65.97 136.41,66.22 136.29,66.33 135.85,66.33 135.74,66.45 135.74,66.68 135.85,66.8 136.29,66.8 136.41,66.92 136.41,67.18 136.24,67.35 135.8,67.35 135.69,67.46 135.69,67.89 124.52,79.06 122.07,79.06
  BOTTOM w0.076: v2(118.01,84.34) 117.3,85.05 117.3,88.72 117.1,88.92 117.1,90.3 117.01,90.39 117.01,91.34 116.77,91.58 116.77,91.83 116.79,91.95 116.79,92.12 116.61,92.3 116.59,92.3 116.47,92.42 UC1.AW29
  BOTTOM w0.112: JDIMM1.229 135.23,60.36 v2(136.26,59.32)
DDR_A_D52: length 48.9
  IN3 w0.076: 120.95,77.35 120.95,77.43 119.5,78.88 119.25,78.88 115.92,82.21 115.92,84.19 116.08,84.34 v2(116.42,84.34)
  IN3 w0.117: 120.95,77.35 120.95,77.1 121.56,76.49 123.49,76.49 132.66,67.33 132.66,63.9 133.15,63.4 133.15,63.06 132.97,62.87 132.97,60.11 131.99,59.14 131.99,58.86 132.11,58.75 132.24,58.75 132.38,58.6 132.38,58.4 132.27,58.28 132.11,58.28 131.99,58.16 131.99,57.8 132.11,57.68 132.44,57.68 v2(132.81,58.05)
  BOTTOM w0.076: UC1.BB31 115.32,90.61 115.32,89.54 115.63,89.23 115.63,85.13 v2(116.42,84.34)
  BOTTOM w0.112: JDIMM1.211 130.73,60.89 131.06,60.55 131.06,59.8 v2(132.81,58.05)
DDR_A_D53: length 49.2
  IN3 w0.076: 121.7,77.35 121.66,77.35 119.67,79.35 119.29,79.35 116.78,81.86 116.78,83.35 v2(116.42,83.7)
  IN3 w0.117: 121.7,77.35 121.85,77.2 123.77,77.2 133.63,67.35 133.63,66.88 133.32,66.57 133.32,65.46 133.86,64.92 133.86,63 134.35,62.52 134.35,60.36 133.63,59.65 133.63,57.3 133.52,57.19 133.34,57.19 133.23,57.07 133.23,56.84 133.34,56.72 133.52,56.72 133.63,56.6 133.63,55.82 133.32,55.51 v2(132.81,55.51)
  BOTTOM w0.076: v2(116.42,83.7) 115.47,84.66 115.47,89.16 115.15,89.47 115.15,90.36 114.98,90.53 114.98,90.79 115.1,91.04 115.1,91.04 115.11,91.05 115.25,91.19 UC1.BA31
  BOTTOM w0.112: v2(132.81,55.51) 131.98,54.67 131.98,53.7 JDIMM1.216
DDR_A_D54: length 49.7
  IN3 w0.076: 121.86,79.72 121.48,79.72 120.04,81.16 119.55,81.16 118.72,82 118.72,82.36 v2(118.01,83.07)
  IN3 w0.117: v2(136.26,56.78) 137.07,57.59 137.07,67.46 124.81,79.72 121.86,79.72
  BOTTOM w0.076: v2(118.01,83.07) 117.14,83.94 117.14,88.65 116.93,88.85 116.93,90.21 116.84,90.3 116.84,90.84 116.57,91.11 UC1.BA29
  BOTTOM w0.112: v2(136.26,56.78) 136.17,56.78 133.98,54.59 133.98,53.7 JDIMM1.224
DDR_A_D55: length 48.5
  IN3 w0.076: 122.07,79.39 121.89,79.39 121.79,79.49 121.33,79.49 120.01,80.81 119.48,80.81 118.49,81.8 118.49,82.21 118.26,82.43 v2(118.01,82.43)
  IN3 w0.117: v2(136.26,58.05) 136.62,58.05 136.74,58.17 136.74,67.32 124.67,79.39 122.07,79.39
  BOTTOM w0.076: UC1.BB29 116.57,90.34 116.77,90.14 116.77,88.72 116.97,88.52 116.97,87.96 116.91,87.9 v4(116.91,87.63) 116.91,83.53 v2(118.01,82.43)
  BOTTOM w0.112: JDIMM1.225 134.23,60.2 135.77,58.66 135.77,58.54 v2(136.26,58.05)
DDR_A_D56: length 52.9
  IN3 w0.076: 119.19,85.63 119.19,82.12 119.63,81.67 119.71,81.67
  IN3 w0.117: v2(138.11,57.85) 138.21,57.75 138.4,57.75 138.57,57.92 138.57,58.17 138.39,58.35 138.12,58.35 138.03,58.45 138.03,58.73 138.15,58.85 138.24,58.85 138.36,58.97 138.36,59.2 138.24,59.32 138.15,59.32 138.03,59.43 138.03,59.65 138.15,59.77 138.22,59.77 138.34,59.89 138.34,60.12 138.22,60.24 138.15,60.24 138.03,60.35 138.03,67.87 125.22,80.68 121.06,80.68 120.07,81.67 119.71,81.67 ; v2(118.01,86.24) 118.85,86.24 119.19,85.9 119.19,85.63
  BOTTOM w0.076: UC1.AY27 117.8,91.89 117.8,91.62 117.87,91.44 117.87,91.23 117.83,91.14 117.83,90.88 117.87,90.79 117.87,90.53 117.76,90.42 117.76,89.39 118.57,88.58 118.57,86.81 v2(118.01,86.24)
  BOTTOM w0.112: v2(138.11,57.85) 137.44,57.17 137.44,56.03 135.98,54.57 JDIMM1.232
DDR_A_D57: length 53.3
  IN3 w0.076: v2(118.01,84.97) 118.34,84.97 118.95,84.36 118.95,82 119.53,81.42 120.06,81.42 121.13,80.35 121.23,80.35
  IN3 w0.117: v2(138.77,56.65) 138.77,56.19 138.65,56.07 137.81,56.07 137.7,56.19 137.7,67.72 125.07,80.35 121.23,80.35
  BOTTOM w0.076: v2(118.01,84.97) 117.59,85.39 117.59,88.85 117.26,89.18 117.26,90.37 117.17,90.46 117.17,91.37 117.38,91.58 117.38,91.59 117.41,91.61 117.41,91.83 117.38,91.95 117.38,92.13 117.7,92.45 UC1.AW27
  BOTTOM w0.112: JDIMM1.236 136.98,54.86 v2(138.77,56.65)
DDR_A_D58: length 52.6
  IN3 w0.117: v2(119.75,82.19) 119.84,82.19 120.19,82.54 121.13,82.54 121.38,82.79 122.76,82.79 124.49,81.06 125.32,81.06 138.37,68.01 138.37,67.47 138.49,67.35 139.04,67.35 139.17,67.22 139.17,67 139.05,66.88 138.49,66.88 138.37,66.77 138.37,66.53 138.49,66.41 139.05,66.41 139.17,66.3 139.17,66.06 139.05,65.95 138.49,65.95 138.37,65.83 138.37,65.6 138.49,65.48 139.05,65.48 139.17,65.36 139.17,65.14 139.05,65.01 138.49,65.01 138.37,64.9 138.37,62.72 138.5,62.6 139.04,62.6 139.17,62.47 139.17,62.22 139.04,62.09 138.5,62.09 138.37,61.96 138.37,61.71 138.5,61.58 139.04,61.58 139.17,61.45 139.17,61.2 139.04,61.07 138.5,61.07 138.36,60.94 138.36,60.57 138.47,60.46 v2(138.77,60.46)
  BOTTOM w0.076: v2(119.75,82.19) 120.23,82.68 120.23,86.99 119.77,87.45 119.77,89.23 119.37,89.63 119.37,90.49 119.37,90.49 119.37,90.81 119.29,90.99 119.2,91.17 119.2,91.51 118.93,91.78 UC1.AY25
  BOTTOM w0.112: JDIMM1.237 137.23,61.9 137.23,60.96 137.72,60.46 v2(138.77,60.46)
DDR_A_D59: length 53.4
  IN3 w0.117: v2(119.73,82.8) 119.98,82.8 120.25,83.08 120.25,83.59 120.37,83.7 120.6,83.7 120.72,83.59 120.72,82.99 120.83,82.88 120.99,82.88 121.24,83.13 122.9,83.13 124.63,81.4 125.47,81.4 139.5,67.37 139.5,64.62 139.39,64.5 139.33,64.5 139.21,64.38 139.21,64.15 139.33,64.03 139.39,64.03 139.5,63.91 139.5,63.68 139.39,63.56 139.33,63.56 139.21,63.45 139.21,63.21 139.33,63.1 139.39,63.1 139.5,62.98 139.5,60.49 139.39,60.38 139.26,60.38 139.14,60.26 139.14,60.03 139.26,59.91 139.39,59.91 139.5,59.79 139.5,59.37 139.13,59 138.96,59 v2(138.77,59.19)
  BOTTOM w0.076: v2(119.73,82.8) 119.73,82.81 118.76,83.79 118.76,88.65 v4(118.34,89.07) 117.96,89.45 117.96,90.39 118.03,90.46 118.03,90.82 118.03,90.82 118,90.91 118,91.11 118.03,91.2 118.03,91.46 118.01,91.53 118.01,92.35 118.29,92.64 UC1.AW25
  BOTTOM w0.112: v2(138.77,59.19) 138.01,59.19 136.23,60.98 JDIMM1.233
DDR_A_D60: length 51.8
  IN3 w0.117: v2(141.47,57.29) 141.87,57.69 141.87,58.45 142.22,58.79 142.22,67.7 139.86,70.05 139.86,70.39 126.36,83.89 125.46,83.89 123.6,85.76 121.81,85.76 120.59,86.98 118.1,86.98 v2(118.01,86.88)
  BOTTOM w0.076: v2(118.01,86.88) 118.37,87.25 118.37,88.54 117.59,89.33 117.59,90.68 UC1.BB27
  BOTTOM w0.112: v2(141.47,57.29) 141.12,57.19 139.93,55.05 139.48,54.6 JDIMM1.246
DDR_A_D61: length 51.8
  IN3 w0.117: v2(118.01,88.15) 118.82,87.34 120.7,87.34 121.94,86.09 123.77,86.09 125.61,84.25 126.48,84.25 140.2,70.53 140.2,70.19 142.58,67.8 142.58,58.67 142.24,58.33 142.24,56.79 v2(141.47,56.02)
  BOTTOM w0.076: UC1.BA27 117.6,91.11 117.34,90.85 117.34,90.53 117.43,90.44 117.43,89.26 118.01,88.68 v2(118.01,88.15)
  BOTTOM w0.112: JDIMM1.250 140.48,55.02 v2(141.47,56.02)
DDR_A_D62: length 51.4
  IN3 w0.117: v2(141.47,58.56) 141.89,58.97 141.89,65.64 141.65,65.88 141.65,66.05 141.89,66.28 141.89,66.62 141.77,66.74 141.48,66.74 141.33,66.89 141.33,67.12 141.43,67.22 141.7,67.22 141.82,67.34 141.82,67.61 141.7,67.73 141.44,67.73 141.33,67.84 141.33,68.12 139.53,69.91 139.53,70.25 126.25,83.54 125.31,83.54 123.88,84.97 123.27,84.97 123.15,85.09 123.15,85.31 123.04,85.43 122.8,85.43 122.69,85.31 122.69,85.09 122.57,84.97 122.11,84.97 121.99,85.09 121.99,85.31 121.88,85.43 121.67,85.43 121.14,85.95 120.98,85.95 120.72,85.7 120.56,85.7 120.39,85.86 120.39,86.03 120.6,86.23 120.6,86.4 120.44,86.56 v2(119.79,86.56)
  BOTTOM w0.076: v2(119.79,86.56) 119.79,87.06 119.57,87.27 119.57,89.1 119.2,89.47 119.2,90.77 119.14,90.91 119.14,90.91 119.08,91.04 118.93,91.19 UC1.BA25
  BOTTOM w0.112: JDIMM1.245 139.23,60.8 v2(141.47,58.56)
DDR_A_D63: length 50.7
  IN3 w0.117: v2(119.79,85.93) 120.42,85.29 121.11,85.29 121.78,84.62 123.71,84.62 125.14,83.18 126.13,83.18 139.2,70.12 139.2,69.77 140.99,67.98 140.99,66.65 141.11,66.54 141.21,66.54 141.33,66.42 141.33,66.19 141.21,66.07 141.11,66.07 140.99,65.95 140.99,65.72 141.11,65.6 141.41,65.6 141.53,65.49 141.53,65.25 141.41,65.14 141.11,65.14 140.99,65.02 140.99,64.79 141.11,64.67 141.41,64.67 141.53,64.55 141.53,64.32 141.41,64.2 141.11,64.2 140.99,64.08 140.99,63.85 141.11,63.73 141.44,63.73 141.55,63.62 141.55,63.38 141.44,63.27 141.11,63.27 140.99,63.15 140.99,62.92 141.11,62.8 141.44,62.8 141.55,62.68 141.55,62.45 141.44,62.33 141.11,62.33 140.99,62.21 140.99,61.98 141.11,61.86 141.44,61.86 141.55,61.75 141.55,61.51 141.44,61.4 141.11,61.4 140.99,61.28 140.99,61.05 141.11,60.93 141.44,60.93 141.55,60.81 141.55,60.58 141.44,60.46 141.11,60.46 140.99,60.35 140.99,59.94 141.11,59.83 v2(141.47,59.83)
  BOTTOM w0.076: UC1.BB25 119.04,90.57 119.04,89.33 119.4,88.96 119.4,86.31 v2(119.79,85.93)
  BOTTOM w0.112: v2(141.47,59.83) 141.13,59.83 140.23,60.74 JDIMM1.249
DDR_A_DQS0: length 62.9
  IN3 w0.124: v2(78.56,57.59) 78.95,57.59 79.33,57.98 79.33,59.16 79,59.49 79,59.7 78.25,60.46 78.25,63.46 78.67,63.88 78.67,76 79.13,76.46 79.13,86.58 79.25,86.71 80.17,86.71 80.42,86.96 80.42,87.51 80.17,87.76 79.25,87.76 79.13,87.88 79.13,88.25 79.25,88.38 79.88,88.38 80.13,88.63 80.13,89.18 79.88,89.43 79.25,89.43 79.13,89.55 79.13,92.93 80.66,94.46 84.88,94.46 85.21,94.8 85.21,95.94 v2(85.42,96.15)
  BOTTOM w0.076: 86.51,95.69 86.52,95.69 86.97,96.13 88.51,96.13 89.23,96.86 90.3,96.86 90.77,97.32 91.55,97.32 91.63,97.24 91.89,97.24 92,97.3 92.22,97.3 92.33,97.24 92.54,97.24 92.62,97.28 92.91,97.28 93.11,97.18 93.18,97.12 93.18,96.98 93.22,96.94 UC1.AM69
  BOTTOM w0.102: 86.51,95.69 85.73,95.69 85.42,96 v2(85.42,96.15)
  BOTTOM w0.112: JDIMM1.13 79.23,59.67 79.4,59.5 79.4,57.92 79.17,57.69 78.66,57.69 v2(78.56,57.59)
DDR_A_DQS1: length 50.1
  IN3 w0.124: v2(83.62,56.62) 83.8,56.44 84.12,56.44 84.18,56.51 84.18,63.7 83.78,64.1 83.78,64.51 83.46,64.83 83.46,70.37 83.78,70.7 83.78,71.12 83.46,71.44 83.46,72.05 83.78,72.37 83.78,72.79 83.46,73.11 83.46,73.72 83.78,74.04 83.78,74.46 83.46,74.78 83.46,75.39 83.78,75.71 83.78,84.1 88.37,88.68 88.37,88.73 88.93,89.29 88.93,89.52 88.8,89.65 v2(88.64,89.65)
  BOTTOM w0.076: 87.97,91.7 87.99,91.7 88.77,92.48 88.77,92.48 90.38,94.09 91.27,94.09 91.43,94.26 91.92,94.26 92.06,94.21 92.17,94.21 92.3,94.26 92.57,94.26 92.65,94.22 92.87,94.22 92.98,94.28 93.01,94.31 93.01,94.47 92.94,94.54 92.81,94.54 UC1.AT70
  BOTTOM w0.112: JDIMM1.34 84.48,54.72 84.33,54.87 84.33,56.22 84.12,56.42 83.68,56.42 83.62,56.49 v2(83.62,56.62) ; v2(88.64,89.65) 88.64,89.65 88.24,90.05 88.06,90.05 87.83,90.28 87.83,91.56 87.97,91.7
DDR_A_DQS2: length 46.8
  IN3 w0.124: v2(90.63,84.48) 90.53,84.58 90.35,84.58 90.19,84.42 90.19,83.09 89.94,82.84 88.72,82.84 88.6,82.72 88.6,74.64 88.29,74.34 88.21,74.34 88.09,74.21 88.09,73.84 88.21,73.72 88.29,73.72 88.54,73.47 88.54,72.92 88.29,72.67 88.21,72.67 88.09,72.54 88.09,65.9 89.28,64.7 89.28,60.07 89.45,59.9 89.45,58.02 89.2,57.77 88.88,57.77 v2(88.75,57.64)
  BOTTOM w0.076: v2(90.63,84.48) 90.63,84.48 90.66,84.51 90.66,85.45 91.16,85.95 91.36,85.95 92.1,86.7 92.1,88.1 92.84,88.83 94.79,88.83 95.66,89.71 95.66,90.4 95.8,90.54 95.8,90.79 95.76,90.89 95.76,91.12 95.81,91.23 95.81,91.44 95.77,91.52 95.77,91.81 95.86,92 95.88,92.03 96.11,92.26 UC1.AY64
  BOTTOM w0.112: v2(88.75,57.64) 88.8,57.68 89.32,57.68 89.56,57.93 89.56,60.88 89.73,61.04 JDIMM1.55
DDR_A_DQS3: length 45.1
  IN3 w0.124: v2(96.25,86.88) 95.96,86.59 95.31,86.59 94.97,86.25 94.97,81.78 92.51,79.32 92.51,67 93.2,66.31 93.2,65.54 94.23,64.51 94.23,57.56 94.1,57.42 93.9,57.42 v2(93.48,57.84)
  BOTTOM w0.076: UC1.BA60 98.61,91.71 98.69,91.71 98.79,91.61 98.79,91.2 98.84,91.07 98.84,90.96 98.79,90.82 98.79,90.46 98.95,90.3 98.95,89.97 98.64,89.66 98.64,89.28 96.75,87.39 96.75,86.62 96.64,86.51 96.47,86.51 96.25,86.73 v2(96.25,86.88)
  BOTTOM w0.112: v2(93.48,57.84) 93.48,57.78 93.69,57.57 94.23,57.57 94.82,56.98 94.82,54.75 94.98,54.59 JDIMM1.76
DDR_A_DQS4: length 47.3
  IN3 w0.124: v2(110.98,85.49) 110.92,85.55 110.92,85.71 110.97,85.76 111.13,85.76 111.32,85.95 111.32,85.98 111.39,86.05 111.58,86.05 111.65,85.98 111.65,80.31 113.82,78.14 113.82,77.56 114.03,77.35 114.03,73.88 118.6,69.31 120.68,69.31 123.5,66.49 123.5,62.34 123.36,62.21 122.52,62.21 122.26,61.94 122.26,61.2 122.52,60.93 123.62,60.93 123.93,60.62 123.93,59.63 123.79,59.48 123.49,59.48 123.32,59.65 v2(123.32,59.74)
  BOTTOM w0.076: UC1.AY38 110.63,92.05 110.54,91.91 110.5,91.8 110.5,91.52 110.53,91.44 110.53,91.23 110.48,91.12 110.48,90.9 110.53,90.79 110.53,90.43 110.42,90.32 110.42,88.69 110.32,88.59 110.32,87.34 110.27,87.3 110.27,86.81 110.32,86.76 110.32,86.1 110.49,85.92 110.69,85.92 110.82,85.8 110.82,85.65 v2(110.98,85.49)
  BOTTOM w0.112: JDIMM1.179 122.73,60.94 122.68,60.9 122.68,59.73 122.88,59.52 123.24,59.52 123.32,59.6 v2(123.32,59.74)
DDR_A_DQS5: length 48.6
  IN3 w0.124: v2(128.77,56.55) 129.49,57.27 129.49,58.28 129.24,58.52 129.24,67.01 122.4,73.85 120.34,73.85 118.34,75.85 118.34,78.14 114.17,82.31 114.17,85.09 114.28,85.2 114.54,85.2 v2(114.58,85.16)
  BOTTOM w0.076: v2(114.58,85.16) 114.25,85.49 114.05,85.49 113.72,85.82 113.72,89.5 113.52,89.71 113.52,90.83 113.57,90.94 113.57,90.96 113.57,91.07 113.52,91.2 113.52,91.47 113.55,91.55 113.55,91.77 113.52,91.83 113.47,91.91 113.43,91.93 113.35,91.93 113.28,91.87 UC1.BA34
  BOTTOM w0.112: v2(128.77,56.55) 128.49,56.83 128.31,56.83 128.2,56.72 128.2,55.28 127.82,54.9 127.82,54.67 127.98,54.52 JDIMM1.200
DDR_A_DQS6: length 49.9
  IN3 w0.124: v2(116.42,85.61) 116.75,85.94 116.91,85.94 117.02,85.83 117.02,81.95 119.19,79.78 119.67,79.78 121.6,77.86 124.01,77.86 134.5,67.37 134.5,66.69 134.38,66.58 134.22,66.58 133.95,66.31 133.95,65.73 134.22,65.46 134.4,65.46 134.51,65.35 134.51,63.27 135,62.78 135,58.88 134.86,58.75 134.47,58.75 v2(134.21,59)
  BOTTOM w0.076: v2(116.42,85.61) 116.13,85.9 116.05,85.9 115.85,86.1 115.85,89.25 115.48,89.61 115.48,90.15 115.51,90.18 115.51,90.79 115.46,90.9 115.46,91.07 arc(115.47,91.12) 115.48,91.16 115.5,91.2 arc(115.51,91.23) 115.51,91.26 115.51,91.8 115.81,92.1 UC1.AY30
  BOTTOM w0.112: v2(134.21,59) 133.94,58.73 133.73,58.73 133.62,58.84 133.62,59.86 133.05,60.43 133.05,60.9 133.23,61.08 JDIMM1.221
DDR_A_DQS7: length 52.8
  IN3 w0.124: v2(140.19,56.96) 139.97,57.19 139.6,57.19 139.33,57.45 139.33,58.31 140.13,59.11 140.13,67.65 125.72,82.06 124.86,82.06 123.14,83.78 121.43,83.78 120.76,84.44 120.21,84.44 v2(119.79,84.02)
  BOTTOM w0.076: UC1.BA26 118.27,91.87 118.32,91.93 118.41,91.93 118.45,91.91 118.5,91.83 118.53,91.77 118.53,91.55 118.49,91.47 118.49,91.19 118.54,91.09 118.54,91.08 118.54,90.94 118.54,90.93 118.49,90.83 118.49,90.43 118.7,90.22 118.7,89.04 118.92,88.82 118.92,84.52 119.18,84.25 119.55,84.25 v2(119.79,84.02)
  BOTTOM w0.112: JDIMM1.242 138.48,54.59 138.33,54.74 138.33,55.04 139.57,56.29 139.57,56.92 139.81,57.16 139.99,57.16 v2(140.19,56.96)
DDR_A_DQS#0: length 62.9
  IN3 w0.124: v2(84.78,96.15) 85,95.94 85,94.89 84.79,94.68 80.58,94.68 78.92,93.02 78.92,89.46 79.16,89.21 79.79,89.21 79.92,89.09 79.92,88.72 79.79,88.59 79.16,88.59 78.92,88.34 78.92,87.79 79.16,87.54 80.08,87.54 80.2,87.42 80.2,87.05 80.08,86.92 79.16,86.92 78.92,86.67 78.92,76.55 78.46,76.09 78.46,63.96 78.03,63.54 78.03,60.37 78.79,59.61 78.79,59.4 79.12,59.07 79.12,58.07 79,57.94 78.82,57.94 v2(78.59,58.18)
  BOTTOM w0.076: UC1.AM70 92.93,96.84 93.01,96.93 93.01,97.04 92.87,97.11 92.65,97.11 92.57,97.08 92.3,97.08 92.17,97.13 92.06,97.13 91.92,97.08 91.56,97.08 91.48,97.16 90.84,97.16 90.37,96.69 89.3,96.69 88.58,95.96 87.04,95.96 86.57,95.49
  BOTTOM w0.102: v2(84.78,96.15) 85.19,95.74 85.39,95.74 85.64,95.49 86.57,95.49
  BOTTOM w0.112: JDIMM1.11 78.73,61.01 78.84,60.89 78.91,60.89 79.02,60.78 79.02,59.59 79.2,59.41 79.2,58.01 79.08,57.89 78.84,57.89 78.59,58.15 v2(78.59,58.18)
DDR_A_DQS#1: length 50
  IN3 w0.124: v2(88.64,90.23) 88.86,90.02 88.89,90.02 89.14,89.77 89.14,89.2 88.58,88.64 88.58,88.59 84,84.01 84,75.62 83.68,75.3 83.68,74.87 84,74.55 84,73.95 83.68,73.63 83.68,73.2 84,72.88 84,72.28 83.68,71.96 83.68,71.53 84,71.21 84,70.61 83.68,70.29 83.68,64.92 84,64.6 84,64.19 84.4,63.79 84.4,56.42 84.21,56.23 83.8,56.23 83.62,56.05 v2(83.62,55.99)
  BOTTOM w0.076: UC1.AT69 93.41,94.46 93.1,94.15 93.1,94.15 92.91,94.06 92.62,94.06 92.54,94.09 92.33,94.09 92.22,94.04 92,94.04 91.89,94.09 91.5,94.09 91.34,93.93 90.46,93.93 88.89,92.36 88.11,91.58 88.11,91.55 88.05,91.49
  BOTTOM w0.112: JDIMM1.32 83.98,54.72 84.12,54.87 84.12,56.13 84.04,56.22 83.85,56.22 v2(83.62,55.99) ; v2(88.64,90.23) 88.62,90.26 88.14,90.26 88.03,90.37 88.03,91.47 88.05,91.49
DDR_A_DQS#2: length 46.9
  IN3 w0.124: v2(88.75,58.22) 88.96,58.01 89.12,58.01 89.23,58.12 89.23,59.81 89.07,59.98 89.07,64.62 87.88,65.81 87.88,72.63 88.13,72.88 88.21,72.88 88.33,73 88.33,73.38 88.21,73.5 88.13,73.5 87.88,73.75 87.88,74.3 88.13,74.55 88.21,74.55 88.39,74.73 88.39,82.8 88.64,83.05 89.86,83.05 89.98,83.18 89.98,84.51 90.37,84.9 90.94,84.9 v2(91.18,84.65)
  BOTTOM w0.076: UC1.BA64 96.21,91.68 96.13,91.76 96.01,91.71 95.94,91.63 95.94,91.55 95.98,91.47 95.98,91.19 95.93,91.08 95.93,90.93 95.97,90.83 95.97,90.47 95.83,90.33 95.83,89.64 94.86,88.66 92.91,88.66 92.27,88.03 92.27,86.63 91.43,85.78 91.23,85.78 90.83,85.38 90.83,84.9 91.08,84.65 v2(91.18,84.65)
  BOTTOM w0.112: v2(88.75,58.22) 88.75,58.22 89.07,57.89 89.23,57.89 89.36,58.02 89.36,60.94 89.23,61.08 JDIMM1.53
DDR_A_DQS#3: length 45
  IN3 w0.124: v2(96.25,86.23) 96.1,86.38 95.4,86.38 95.18,86.16 95.18,81.69 92.72,79.23 92.72,67.09 93.41,66.4 93.41,65.63 94.44,64.6 94.44,57.47 94.18,57.21 93.72,57.21 93.71,57.2 v2(93.48,57.2)
  BOTTOM w0.076: v2(96.25,86.23) 96.36,86.35 96.71,86.35 96.91,86.55 96.91,87.32 98.8,89.21 98.8,89.59 99.12,89.9 99.12,90.37 98.96,90.53 98.96,90.79 99.01,90.9 99.01,91.12 98.96,91.23 98.96,91.68 98.66,91.98 UC1.AY60
  BOTTOM w0.112: JDIMM1.74 94.48,54.61 94.61,54.75 94.61,56.89 94.14,57.36 93.65,57.36 v2(93.48,57.2)
DDR_A_DQS#4: length 47.3
  IN3 w0.124: v2(123.32,59.1) 123.32,59.15 123.45,59.27 123.87,59.27 124.14,59.54 124.14,60.71 123.7,61.15 122.61,61.15 122.47,61.29 122.47,61.85 122.61,61.99 123.45,61.99 123.71,62.25 123.71,66.57 120.76,69.52 118.69,69.52 114.25,73.97 114.25,77.44 114.03,77.65 114.03,78.23 111.86,80.4 111.86,86.07 111.66,86.26 111.1,86.26 v2(110.98,86.14)
  BOTTOM w0.076: UC1.BA38 110.93,91.67 110.93,91.81 arc(110.9,91.9) 110.82,91.96 110.81,91.96 arc(110.79,91.96) 110.77,91.95 110.75,91.93 arc(110.74,91.91) 110.73,91.89 110.71,91.86 arc(110.69,91.83) 110.68,91.8 110.67,91.78 arc(110.66,91.77) 110.66,91.75 110.66,91.57 arc(110.67,91.55) 110.67,91.53 110.69,91.5 arc(110.7,91.47) 110.7,91.44 110.7,91.2 110.64,91.07 110.64,90.96 110.7,90.82 110.7,90.79 110.7,90.36 110.59,90.25 110.59,88.62 110.49,88.52 v4(110.49,87.03) 110.49,86.17 110.56,86.09 110.93,86.09 v2(110.98,86.14)
  BOTTOM w0.112: v2(123.32,59.1) 123.1,59.32 122.8,59.32 122.47,59.64 122.47,60.75 122.23,60.99 JDIMM1.177
DDR_A_DQS#5: length 48.7
  IN3 w0.124: v2(128.77,57.18) 129.1,57.18 129.27,57.35 129.27,58.19 129.03,58.43 129.03,66.92 122.31,73.63 120.26,73.63 118.13,75.76 118.13,78.05 113.95,82.22 113.95,85.17 v2(114.58,85.8)
  BOTTOM w0.076: UC1.AY34 113.38,92.12 113.4,92.1 113.46,92.1 113.54,92.07 113.59,92.05 113.67,91.91 113.72,91.8 113.72,91.52 113.68,91.44 113.68,91.23 113.73,91.12 113.73,90.9 113.68,90.79 113.68,89.78 113.89,89.56 113.89,85.89 114.12,85.66 114.44,85.66 v2(114.58,85.8)
  BOTTOM w0.112: JDIMM1.198 127.48,54.53 127.47,54.53 127.62,54.67 127.62,54.99 127.99,55.36 127.99,56.81 128.23,57.04 128.63,57.04 v2(128.77,57.18)
DDR_A_DQS#6: length 49.8
  IN3 w0.124: v2(116.42,86.24) 116.51,86.15 117,86.15 117.23,85.92 117.23,82.04 119.28,80 119.76,80 121.68,78.07 124.09,78.07 134.71,67.46 134.71,66.6 134.47,66.36 134.31,66.36 134.17,66.22 134.17,65.81 134.31,65.67 134.49,65.67 134.73,65.44 134.73,63.35 135.21,62.87 135.21,58.79 134.95,58.53 134.38,58.53 v2(134.21,58.37)
  BOTTOM w0.076: UC1.BA30 115.78,91.66 115.68,91.56 115.68,91.2 115.63,91.07 115.63,90.96 115.63,90.94 115.68,90.83 115.68,90.11 115.65,90.08 115.65,89.68 116.02,89.31 116.02,86.17 116.09,86.09 116.26,86.09 116.41,86.24 v2(116.42,86.24)
  BOTTOM w0.112: JDIMM1.219 132.73,61.07 132.84,60.96 132.84,60.35 133.41,59.78 133.41,58.76 133.64,58.52 134.05,58.52 v2(134.21,58.37)
DDR_A_DQS#7: length 52.8
  IN3 w0.124: v2(140.19,57.6) 139.99,57.4 139.69,57.4 139.55,57.54 139.55,58.22 140.34,59.02 140.34,67.74 125.81,82.27 124.95,82.27 123.23,83.99 121.52,83.99 120.85,84.66 v2(119.79,84.66)
  BOTTOM w0.076: UC1.AY26 118.36,92.12 118.38,92.1 118.44,92.1 118.57,92.05 118.65,91.91 118.7,91.8 118.7,91.52 118.66,91.44 118.66,91.23 118.69,91.16 118.72,91.11 118.72,90.91 118.7,90.86 118.66,90.79 118.66,90.5 118.87,90.29 118.87,89.11 119.14,88.85 v4(119.14,87.82) 119.14,85.81 119.09,85.77 119.09,84.59 119.26,84.42 119.55,84.42 v2(119.79,84.66)
  BOTTOM w0.112: JDIMM1.240 137.98,54.59 138.12,54.73 138.12,55.13 139.37,56.37 139.37,57.01 139.73,57.37 139.96,57.37 v2(140.19,57.6)
DDR_A_MA0: length 43
  IN3 w0.076: 104.2,77.35 104.2,86.19 v2(102.87,87.51)
  IN3 w0.183: v2(112.31,55.72) 112.29,55.72 109.93,58.08 109.93,63.88 104.2,69.62 104.2,77.35
  BOTTOM w0.076: UC1.AY50 104.18,91.83 103.98,91.63 103.9,91.41 103.9,91.28 103.97,91.05 103.97,90.91 103.95,90.88 103.94,90.87 103.91,90.79 103.91,90.54 104.04,90.42 104.04,89.79 103.46,89.21 103.46,88.1 v2(102.87,87.51)
  BOTTOM w0.183: v2(112.31,55.72) 112.31,55 111.98,54.67 JDIMM1.144
DDR_A_MA1: length 43.4
  IN3 w0.076: 103.73,77.35 103.73,78.04 103.56,78.21 103.56,80.62 103.86,80.92 103.86,86.29 103.27,86.88 v2(102.87,86.88)
  IN3 w0.183: v2(108.83,60.43) 108.83,60.41 109.02,60.22 109.29,60.22 109.47,60.4 109.47,61.09 109.29,61.27 108.79,61.27 108.61,61.45 108.61,61.82 108.79,62 109.29,62 109.47,62.18 109.47,62.63 109.27,62.83 108.57,62.83 108.39,63.01 108.39,63.46 108.99,64.06 108.99,64.17 103.73,69.42 103.73,77.35
  BOTTOM w0.076: v2(102.87,86.88) 102.87,86.75 103.22,86.39 103.22,85.08 103.3,85 103.76,85 103.85,85.09 103.85,89.35 104.26,89.77 104.26,90.6 UC1.BB50
  BOTTOM w0.183: v2(108.83,60.43) 108.96,60.3 109.22,60.3 109.43,60.51 109.43,60.89 109.23,61.09 JDIMM1.133
DDR_A_MA2: length 45.5
  IN3 w0.076: 103.27,77.35 103.27,77.94 103.1,78.11 103.1,80.48 103.48,80.86 103.48,85 v2(102.87,85.61)
  IN3 w0.183: 103.27,77.35 103.27,69.23 107.92,64.58 107.92,62.72 108.14,62.5 108.14,59.47 108.33,59.28 109.15,59.28 109.34,59.1 109.34,57.1 v2(108.86,56.63)
  BOTTOM w0.076: v2(102.87,85.61) 102.06,86.42 102.06,87.2 103.29,88.44 103.29,89.33 103.87,89.91 103.87,90.35 103.75,90.48 103.75,90.83 103.79,90.94 103.79,91.06 103.73,91.28 103.73,91.42 103.78,91.58 103.78,92.08 UC1.AY51
  BOTTOM w0.183: JDIMM1.132 108.98,55.12 109.16,55.31 109.81,55.31 109.99,55.49 109.99,55.86 109.81,56.04 108.9,56.04 108.72,56.22 108.72,56.48 v2(108.86,56.63)
DDR_A_MA3: length 43.8
  IN3 w0.076: v2(102.87,84.97) 103.25,84.59 103.25,80.98 102.79,80.53 102.79,77.35
  IN3 w0.183: 102.79,77.35 102.79,69.06 107.26,64.59 107.26,63.94 106.8,63.48 106.8,63.1 107.68,62.22 107.68,59.28 107.81,59.15 107.81,57.57 107.99,57.39 108.33,57.39 108.83,57.89 v2(108.83,57.89)
  BOTTOM w0.076: v2(102.87,84.97) 103.05,84.8 103.81,84.8 104.01,85 104.01,89.25 104.43,89.67 104.43,91.08 UC1.BA50
  BOTTOM w0.183: JDIMM1.131 108.73,61.06 108.39,60.72 108.39,58.34 108.83,57.9 v2(108.83,57.89)
DDR_A_MA4: length 44.2
  IN3 w0.076: v2(101,85.32) 101.44,85.32 101.62,85.14 101.62,81.44 101.14,80.96 101.14,78.67 100.74,78.27 100.74,77.35
  IN3 w0.183: v2(107.54,55.52) 107.15,55.52 105.55,57.12 105.55,61.62 104.43,62.74 104.43,64.8 100.36,68.88 100.36,69.28 99.69,69.94 99.69,75.52 100.74,76.56 100.74,77.35
  BOTTOM w0.076: v2(101,85.32) 101.36,85.69 101.36,87.24 102.75,88.63 102.75,90.59 UC1.BB52
  BOTTOM w0.183: v2(107.54,55.52) 107.54,55.68 107.73,55.86 108.35,55.86 108.53,55.68 108.53,55.07 107.98,54.52 JDIMM1.128
DDR_A_MA5: length 46.3
  IN3 w0.076: 101.7,77.35 101.7,78.17 102.06,78.53 102.06,81.09 102.13,81.16 102.13,83.5 102.31,83.68 v2(102.87,83.68)
  IN3 w0.183: 101.7,77.35 101.7,76.22 100.64,75.16 100.64,74.87 100.87,74.65 100.87,74.14 100.64,73.91 100.64,73.41 100.87,73.18 100.87,72.68 100.64,72.45 100.64,71.95 100.87,71.72 100.87,71.22 100.64,70.99 100.64,70.31 100.86,70.09 101.6,70.09 101.81,69.88 101.81,68.73 102.33,68.21 102.33,68.21 105.88,64.66 105.88,62.65 106.47,62.06 106.47,59.66 106.66,59.47 106.75,59.47 106.93,59.29 106.93,59.02 106.73,58.81 106.58,58.81 106.47,58.71 106.47,58.39 106.66,58.2 107.28,58.2 v2(107.36,58.28)
  BOTTOM w0.076: UC1.BA51 103.29,91.44 103.29,91.21 103.29,91.2 103.28,91.2 103.28,91.2 103.25,91.11 103.25,90.91 103.28,90.82 103.28,90.46 103.09,90.26 103.09,88.49 101.71,87.11 101.71,83.88 101.9,83.68 v2(102.87,83.68)
  BOTTOM w0.183: JDIMM1.126 107.48,54.82 106.9,55.39 106.9,57.88 107.31,58.28 v2(107.36,58.28)
DDR_A_MA6: length 44.7
  IN3 w0.076: 101.22,77.35 101.22,78.12 101.6,78.5 101.6,81.03 101.88,81.31 101.88,85.15 v2(101.01,86.02)
  IN3 w0.183: v2(107.59,56.96) 107.3,57.25 106.75,57.25 106.01,57.98 106.01,61.84 105.36,62.49 105.36,64.53 100.82,69.07 100.82,69.47 100.18,70.11 100.18,75.35 101.22,76.39 101.22,77.35
  BOTTOM w0.076: UC1.BA52 102.59,91.07 102.59,88.69 101.01,87.12 v2(101.01,86.02)
  BOTTOM w0.183: JDIMM1.127 107.73,61.04 107.81,60.96 107.81,57.17 v2(107.59,56.96)
DDR_A_MA7: length 46
  IN3 w0.076: 98.26,77.35 98.26,79.69 99.46,80.89 99.46,81.88 100.06,82.48 100.37,82.48 100.64,82.74 100.64,83.9 100.76,84.02 v2(101.01,84.02)
  IN3 w0.183: 98.26,77.35 98.26,69.42 98.97,68.7 98.97,68.3 103.04,64.23 103.04,62.16 103.87,61.34 103.87,57.66 104.05,57.47 104.37,57.47 v2(104.79,57.89)
  BOTTOM w0.076: UC1.AW52 102.63,92.24 102.63,91.58 102.42,91.37 102.42,88.86 v4(100.83,87.27) 100.61,87.06 100.61,84.41 v2(101.01,84.02)
  BOTTOM w0.183: JDIMM1.122 106.48,54.53 106.02,54.99 106.02,56.67 v2(104.79,57.89)
DDR_A_MA8: length 44.6
  IN3 w0.076: v2(102.87,83.04) 102.87,83.18 102.77,83.27 102.44,83.27 102.34,83.17 102.34,82.55 102.51,82.37 102.51,81.06 102.41,80.96 102.41,78.32 102.18,78.09 102.18,77.35
  IN3 w0.183: v2(107.19,60.43) 107.2,60.44 107.2,60.7 106.98,60.93 106.98,61.37 107.22,61.61 107.22,62 106.34,62.88 106.34,63.67 106.8,64.13 106.8,64.39 102.27,68.92 102.27,70.36 102.06,70.57 101.54,70.57 101.38,70.73 101.38,71.09 101.56,71.27 102.11,71.27 102.27,71.43 102.27,71.8 102.09,71.98 101.54,71.98 101.35,72.16 101.35,72.53 101.54,72.71 102.11,72.71 102.3,72.89 102.3,73.18 102.11,73.36 101.51,73.36 101.33,73.54 101.33,73.91 101.49,74.07 102.14,74.07 102.32,74.25 102.32,74.62 102.14,74.8 101.72,74.8 101.51,75.01 101.51,75.37 101.69,75.56 101.98,75.56 102.18,75.76 102.18,77.35
  BOTTOM w0.076: v2(102.87,83.04) 102.72,82.89 101.65,82.89 101.54,83 101.54,87.18 102.92,88.56 102.92,90.33 103.12,90.53 103.12,90.79 103.08,90.88 103.08,90.89 103.08,91.14 103.12,91.23 103.12,91.55 103.15,91.58 103.15,91.59 103.26,91.69 103.26,91.91 103.19,91.99 UC1.AY52
  BOTTOM w0.183: JDIMM1.125 107.23,60.47 v2(107.19,60.43)
