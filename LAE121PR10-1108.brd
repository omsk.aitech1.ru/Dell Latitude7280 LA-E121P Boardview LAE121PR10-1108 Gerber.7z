# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_D1: length 53.8
  BOTTOM w0.076: UC1.AW3 131.5,92.28 131.98,92.28 132.14,92.12 132.54,92.12 133.59,91.07 135.55,91.07
  BOTTOM w0.112: 135.55,91.07 136.09,91.07 140.47,86.69 143.36,86.69 v1(145.96,89.29) 147.43,90.76 150.58,90.76 151.18,90.16 158.24,90.16 158.37,90.03 160.58,90.03 161.49,89.11 162.18,89.11 163,89.93 165.88,89.93 167.59,91.64 167.59,97.47 166.15,98.91 JSPI1.15 163.2,98.91 162.83,99.29 RC34.1
PCH_SPI_D1_0_R: length 12.7
  TOP w0.112: v2(159.47,94.18) 159.28,93.99 158.31,93.99 158.13,94.17 RPC1.8
  BOTTOM w0.112: v2(159.47,94.18) 159.47,94.09 159.03,93.65 158.87,93.65 158.6,93.92 158.6,94.08 159.06,94.54 159.06,94.7 158.9,94.85 158.74,94.85 158.28,94.39 158.13,94.39 157.97,94.55 157.97,94.71 158.41,95.16 158.41,95.32 158.26,95.47 158.1,95.47 157.65,95.03 157.49,95.03 157.34,95.18 157.34,95.73 157.56,95.95 158.53,95.95 159.9,94.58 159.9,94.45 160.3,94.05 UC5.2
PCH_SPI_D1_1_R: length 14.3
  TOP w0.112: RC410.2 158.69,98.79 159.8,98.79 159.91,98.9 159.91,99.9 160.02,100.01 160.24,100.01 160.35,99.9 160.35,98.9 160.47,98.79 160.69,98.79 160.8,98.9 160.8,99.9 160.91,100.01 161.14,100.01 161.25,99.9 v1(161.25,99.12) 161.25,98.9 161.36,98.79 162.27,98.79 162.43,98.94 162.43,100.43 162.32,100.54 159.55,100.54 v2(159.41,100.4)
  BOTTOM w0.107: UC6.2 159.85,99.96 v2(159.41,100.4)
PCH_SPI_D1_2_R: length 5.6
  TOP w0.112: v2(157.24,106.59) 157.88,107.22 159.02,107.22 v1(159.85,106.39) 160.6,105.64 RZ58.2
  BOTTOM w0.112: UZ12.24 157.33,106.67 v2(157.24,106.59)
PCH_SPI_D1_R1: length 25.6
  TOP w0.112: RPC1.1 158.13,97.4 RC410.1 159.3,98.57 162.55,98.57 162.66,98.68 162.66,102.45 162.55,102.56 v2(161.7,102.56) v1(161.7,103.72) 161.7,104.99 RZ58.1
  BOTTOM w0.112: v2(161.7,102.56) 161.94,102.56 162.91,103.54 164.97,103.54 166.8,101.71 166.8,99.76 166.45,99.41 JSPI1.16 163.76,99.41 RC34.2
PCH_SPI_D2: length 41.2
  TOP w0.112: v2(159.47,92.29) 158.53,91.34 151.39,91.34 v2(150.7,92.03)
  BOTTOM w0.076: 135.55,91.3 133.59,91.3 132.88,92.01 132.88,92.4 132.54,92.74 131.89,92.74 UC1.AW2
  BOTTOM w0.112: JSPI1.9 164.92,95.91 164.73,95.72 164.73,95.53 164.13,94.93 164.13,94.32 163.73,93.91 RC38.1 163.65,93.91 163.07,93.33 162.62,93.33 161.44,92.15 159.61,92.15 v2(159.47,92.29) ; 135.55,91.3 136.22,91.3 140.58,86.94 143.14,86.94 147.44,91.25 v1(147.9,91.25) RC11.2 149.91,91.25 v2(150.7,92.03)
PCH_SPI_D2_0_R: length 13.2
  TOP w0.112: v2(162.33,93.67) 162.33,93.31 162.53,93.1 163.97,93.1 164.08,93.21 164.08,95.39 163.97,95.5 163.76,95.5 163.65,95.39 163.65,94.53 163.53,94.42 163.31,94.42 163.2,94.53 163.2,95.39 163.09,95.5 162.86,95.5 162.75,95.39 162.75,94.53 162.64,94.42 v3(162.42,94.42) 162.3,94.53 162.3,95.39 162.19,95.5 RC39.2
  BOTTOM w0.112: UC5.3 161.76,92.78 162.33,93.36 v2(162.33,93.67)
PCH_SPI_D2_1_R: length 14.2
  TOP w0.112: v2(159.47,98.12) 159.71,98.36 164.18,98.36 164.3,98.25 v1(164.3,98.05) 164.3,97.87 164.18,97.76 163.51,97.76 163.4,97.64 163.4,96.95 163.29,96.84 163.07,96.84 162.95,96.95 162.95,97.64 162.84,97.76 162.62,97.76 162.51,97.64 162.51,96.95 162.4,96.84 162.17,96.84 162.06,96.95 162.06,97.64 161.95,97.76 160.59,97.76 160.48,97.64 RC43.2
  BOTTOM w0.112: v2(159.47,98.12) 160.04,98.69 UC6.3
PCH_SPI_D2_R1: length 12.5
  TOP w0.112: RC43.1 161.39,96.43 RC39.1 RC30.1 160.25,96.18 160.25,96.07 159.89,95.72 159.89,93.97 v2(159.47,93.55)
  BOTTOM w0.112: v2(159.47,93.55) 159.6,93.42 161.5,93.42 162.39,94.3 v1(162.59,94.3) 162.96,94.3 163.49,94.83 RC38.2 164.46,95.63 164.46,95.98 164.89,96.41 JSPI1.10
PCH_SPI_D3: length 44.6
  BOTTOM w0.076: UC1.AU4 130.65,93.89 130.91,93.63 132.66,93.63 132.73,93.69 134.59,93.69 135.55,92.73
  BOTTOM w0.112: 135.55,92.73 v1(135.81,92.47) 136.07,92.21 136.77,92.21 137.35,91.63 137.35,90.75 140.28,87.82 143.71,87.82 148.55,92.66 150.94,92.66 151.85,91.75 151.85,91.29 152.2,90.94 158.82,90.94 159,90.77 161.64,90.77 162.01,91.13 162.01,91.95 162.43,92.37 163.17,92.37 163.46,92.07 RC40.1 163.78,92.07 164.41,92.71 164.41,93.74 164.69,94.02 164.69,94.73 164.87,94.91 JSPI1.7
PCH_SPI_D3_0_R: length 12.9
  TOP w0.112: v2(156.31,93.86) 156.63,94.18 RPC1.5
  BOTTOM w0.112: v2(156.31,93.86) 156.1,93.66 155.01,93.66 154.9,93.77 v2(154.9,94.66) 154.9,95.18 155.01,95.29 155.23,95.29 155.34,95.18 155.34,94.87 155.45,94.76 155.68,94.76 155.79,94.87 155.79,95.18 155.9,95.29 156.3,95.29 156.41,95.18 156.41,95.07 156.52,94.96 156.81,94.96 156.92,95.07 156.92,95.45 156.63,95.74 155.01,95.74 154.9,95.85 154.9,95.91 154.79,96.02 154.57,96.02 154.46,95.91 154.46,94.17 154.34,94.05 UC5.7
PCH_SPI_D3_1_R: length 14.2
  TOP w0.112: RC407.2 155.85,99.35 155.57,99.63 155.57,102.49 155.69,102.6 156.01,102.6 156.12,102.49 156.12,99.94 v1(156.25,99.82) v2(156.62,99.45)
  BOTTOM w0.107: UC6.7 154.24,99.96 155.43,101.15 157.11,101.15 157.34,100.92 157.34,99.7 157.09,99.45 v2(156.62,99.45)
PCH_SPI_D3_R1: length 21.5
  TOP w0.112: RPC1.4 156.63,96.46 v2(156.42,96.66) 155.85,97.23 RC407.1 ; RC31.1 RC316.1 159.65,92.73 v2(159.47,92.91)
  BOTTOM w0.107: v2(159.47,92.91) 159.31,92.91 157.64,94.58 157.49,94.58 157.39,94.48 157.24,94.48 157.09,94.64 157.09,94.79 157.13,94.83 157.13,95.53 156.34,96.33 156.34,96.57 v2(156.42,96.66)
  BOTTOM w0.112: JSPI1.8 164.97,95.41 164.44,94.88 164.44,94.14 164.16,93.86 164.16,93.48 RC40.2 163.46,92.78 v1(162.66,92.78) 162.46,92.78 161.76,92.09 161.76,91.26 161.49,90.99 159.36,90.99 158.85,91.5 158.85,92.29 v2(159.47,92.91)
PCH_SPI_DO2_XDP: length 109
  IN2 w0.124: v2(141.48,125.83) 139.58,123.93 139.58,123.18 140.54,122.22 140.54,118.8 138.96,117.22 138.96,112.51 139.29,112.18 139.29,111.48 142.75,108.02 142.75,101.74 141.88,100.87 141.88,100.39 142.14,100.14 143.53,100.14 143.92,100.52 145.67,100.52 147.24,98.94 147.75,98.94 148.06,99.25 149.38,99.25 150.72,97.9 150.72,92.69 v2(150.08,92.04)
  BOTTOM w0.112: RC11.1 149.96,92.16 v2(150.08,92.04) ; JXDP1.60 85.81,133.94 v1(86.49,134.62) 87.29,135.42 125.8,135.42 126.54,134.68 126.54,132.95 128.88,130.62 130.05,130.62 134.38,126.28 141.03,126.28 v2(141.48,125.83)
PCH_SPI_DO_XDP: length 94.5
  TOP w0.112: RC133.1 RC10.1 v1(151.5,100.35) 152.02,100.87 152.02,102.12 149.12,105.01 147.15,105.01 144.97,107.2 v2(141.2,107.2)
  IN2 w0.124: v2(88.6,125.61) 90.65,127.65 104.15,127.65 104.47,127.97 109.57,127.97 109.88,127.66 118.79,127.66 119.18,128.05 122.02,128.05 122.76,127.31 125.39,127.31 125.72,127.65 128.32,127.65 128.89,127.09 138.63,127.09 138.97,126.75 138.97,125.5 138.11,124.64 138.11,122.46 139.09,121.48 139.09,119.77 136.97,117.65 136.97,112.53 137.93,111.57 137.93,110.29 141.02,107.2 v2(141.2,107.2)
  BOTTOM w0.112: v2(88.6,125.61) 88.48,125.73 RC128.1
PCI_CLK_LPC1: length 14.9
  TOP w0.112: RC22.1 137.5,85.55 v2(137.36,85.69)
  BOTTOM w0.076: 130.22,88.68 128.98,89.93 128.5,89.93 128.04,90.38 127.4,90.38 127.25,90.53 127.25,90.79 127.31,90.91 127.31,91.05 127.24,91.28 127.24,91.4 127.31,91.61 UC1.AY9
  BOTTOM w0.102: 130.22,88.68 130.63,88.68
  BOTTOM w0.112: 130.63,88.68 131.94,87.37 v1(132.31,87.37) 134.32,87.37 135.13,86.56 136.49,86.56 v2(137.36,85.69)
PCIE_PRX_C_DTX_N1: length 2.7
  TOP w0.104: CR14.2 271.31,63.06 271.75,63.06 272.26,63.56 272.72,63.56 272.81,63.47 UR1.8
PCIE_PRX_C_DTX_N5: length 4.6
  TOP w0.076: 26.54,107.68 26.69,107.53 26.69,107 26.83,106.87 26.83,106.44 UT1.F22
  TOP w0.104: CT130.1 26.13,110.16 26.13,109.89 26.14,109.89 26.16,109.86 26.16,109.13 26.13,109.1 26.13,108.09 26.54,107.68
PCIE_PRX_C_DTX_N6: length 4.6
  TOP w0.076: 28.1,108.23 28.1,108.22 28.09,108.23 28.08,108.22 28.54,107.76 28.54,106.99 28.67,106.87 28.67,106.44 UT1.K22
  TOP w0.104: 28.1,108.23 28.03,108.3 28.03,109.75 28.1,109.82 28.1,110.15 CT128.1
PCIE_PRX_C_DTX_N7: length 3.7
  TOP w0.076: 30.18,108.23 30.18,108.22 30.2,108.2 30.2,107.02 30.04,106.87 30.04,106.45 30.14,106.35 UT1.P22
  TOP w0.104: CT9.1 30.18,109.45 30.18,109.06 30.15,109.03 30.15,108.44 30.18,108.41 30.18,108.23
PCIE_PRX_C_DTX_N8: length 2.7
  TOP w0.076: 32.73,107.91 32.71,107.89 32.71,107.68 32.34,107.31 32.34,106.43 UT1.V22
  TOP w0.104: CT7.1 32.73,108.37 32.73,107.91
PCIE_PRX_C_DTX_N9: length 2.4
  TOP w0.104: UL1.39 242.72,127.33 242.6,127.45 242.38,127.45 242.03,127.8 241.62,127.8 CL2.2
PCIE_PRX_C_DTX_P1: length 2.7
  TOP w0.104: CR13.2 271.32,63.26 271.63,63.26 v4(271.89,63.52) 272.13,63.76 272.72,63.76 272.82,63.87 UR1.7
PCIE_PRX_C_DTX_P5: length 4.5
  TOP w0.076: 26.4,107.54 26.52,107.42 26.52,107 26.37,106.85 26.37,106.59 26.46,106.51 26.55,106.51 26.6,106.56 UT1.F23
  TOP w0.104: 26.4,107.54 25.93,108.01 25.93,110.15 CT129.1
PCIE_PRX_C_DTX_P6: length 4.6
  TOP w0.076: UT1.K23 28.44,106.56 28.39,106.51 28.3,106.51 28.21,106.59 28.21,106.85 28.37,107.01 28.37,107.69 27.83,108.23 27.83,108.23
  TOP w0.104: CT127.1 27.9,110.15 27.9,109.9 27.83,109.83 27.83,109.53 27.8,109.5 27.8,108.81 27.83,108.78 27.83,108.23
PCIE_PRX_C_DTX_P7: length 3.7
  TOP w0.076: 30.38,108.23 30.38,108.22 30.37,108.2 30.37,107 30.52,106.85 30.52,106.51 30.47,106.46 30.35,106.46 30.28,106.52 UT1.P23
  TOP w0.104: 30.38,108.23 30.38,109.45 CT8.1
PCIE_PRX_C_DTX_P8: length 2.7
  TOP w0.076: UT1.V23 32.12,106.56 32.07,106.51 31.97,106.51 31.89,106.59 31.89,106.95 32.17,107.23 32.17,107.38 32.54,107.75 32.54,107.9 32.53,107.91
  TOP w0.104: 32.53,107.91 32.53,108.37 CT6.1
PCIE_PRX_C_DTX_P9: length 2.4
  TOP w0.104: CL1.2 241.62,128 242.11,128 242.47,127.65 242.66,127.65 242.74,127.73 UL1.38
PCIE_PRX_DTX_N1: length 219.4
  TOP w0.104: CR14.1 269.67,63.07 269.24,63.07 v2(269.05,62.88)
  IN1 w0.119: v2(125.65,108.87) 126.14,109.35 126.14,110.27 126.64,110.78 126.64,111.95 126.93,112.24 132.09,112.24 133.24,113.38 137.14,113.38 137.92,112.61 137.92,111.77 140.29,109.39 146.04,109.39 147.63,110.98 150.93,110.98 152.58,109.33 152.58,106.39 154.41,104.57 154.41,100.67 154.89,100.19 154.89,95.57 154.25,94.93 154.25,89.14 152.13,87.02 152.13,83.95 150.83,82.65 150.83,72.01 151.9,70.94 163.06,70.94 163.68,71.56 171.79,71.56 174.03,69.33 175.38,69.33 180.68,64.03 180.68,63.37 181.63,62.42 214.79,62.42 215.59,61.62 219.06,61.62 219.42,61.98 226.38,61.98 227.04,61.31 230.07,61.31 232.56,63.8 232.56,66.69 234.17,68.3 244.66,68.3 245.6,69.23 249.5,69.23 251.39,71.12 255.22,71.12 257,72.91 258.98,72.91 259.7,73.63 262.72,73.63 263.42,74.33 268.17,74.33 269.83,72.67 269.83,69.15 267.62,66.94 267.62,63.45 268.19,62.88 v2(269.05,62.88)
  BOTTOM w0.076: v2(125.65,108.87) 125.42,108.64 UC1.H13
PCIE_PRX_DTX_N3: length 148.8
  IN1 w0.119: v2(122.98,108.92) 123.14,109.08 123.37,109.08 123.6,109.32 123.6,111.8 125.27,113.47 130.34,113.47 130.67,113.81 130.67,114.08 131.47,114.87 139,114.87 140.73,116.61 143.27,116.61 146.78,113.09 151.21,113.09 153.55,110.75 155.5,110.75 157.35,108.9 157.71,108.9 158.92,107.69 159.34,107.69 160.18,106.85 160.18,106.39 163.42,103.15 163.42,99.75 arc(166.13,86.14) 173.84,74.6 174.57,73.87 arc(184.34,67.34) 195.88,65.04 221.25,65.04 221.69,64.6 227.23,64.6 231.75,69.12 231.75,70.24 231.83,70.32 232.04,70.32 232.07,70.29 232.1,70.29 232.24,70.15 232.24,70.03 v2(232.21,70)
  BOTTOM w0.089: UC1.H16 123.33,108.64 123.04,108.93 122.98,108.93 v2(122.98,108.92)
  BOTTOM w0.104: v2(232.21,70) 232.27,70.06 232.27,70.13 232.43,70.29 232.59,70.29 232.73,70.15 JNGFF1.43
PCIE_PRX_DTX_N4: length 145.2
  IN1 w0.119: v2(124.71,108.91) 124.83,108.91 125.26,109.34 125.26,109.65 125.34,109.73 125.34,112.32 125.92,112.9 132.09,112.9 132.66,113.47 132.66,113.75 132.86,113.95 132.86,114.17 132.92,114.23 137.29,114.23 138.58,112.94 138.58,112.07 140.56,110.09 145.34,110.09 147.63,112.38 151.01,112.38 153.34,110.05 155.08,110.05 158.09,107.05 159.07,107.05 159.38,106.73 159.38,106.24 162.74,102.89 162.74,99.75 arc(165.49,85.88) 173.35,74.11 174.08,73.38 arc(174.43,73.04) 174.79,72.7 arc(184.5,66.55) 195.78,64.4 220.82,64.4 221.27,63.95 227.55,63.95 227.93,64.33 228.04,64.44 228.64,64.44 228.77,64.32 228.8,64.32 v2(229.07,64.05)
  BOTTOM w0.076: UC1.G15 v2(124.71,108.91)
  BOTTOM w0.104: v2(229.07,64.05) 229.29,64.27 v4(230.59,64.27) 232.43,64.27 232.56,64.15 JNGFF1.67
PCIE_PRX_DTX_N5: length 129.5
  TOP w0.104: v2(36.09,113.4) 36.09,113.45 35.74,113.81 35.55,113.81 35.34,113.59 35.34,112.73 34.76,112.15 27.84,112.15 27.46,111.77 26.11,111.77 25.94,111.61 25.94,111.34 26.1,111.19 26.1,111.14 CT130.2
  IN3 w0.076: 122.63,111.58 122.63,111.57 122.65,111.56 122.65,111.33 122.35,111.04 122.35,110.53 122.53,110.34 122.85,110.34 v2(122.96,110.23)
  IN3 w0.135: 122.63,111.58 122.63,115.26 121,116.89 121,118.39 120.56,118.83 120.56,124.1 119.32,125.34 117.7,125.34 116.39,126.64 105.47,126.64 104.13,127.98 101.92,127.98 100.68,129.22 90.5,129.22 89.31,128.03 86.08,128.03 85.39,127.33 83.3,127.33 80.42,124.45 75.73,124.45 75.13,125.06 74.57,125.06 74.22,124.71 73.39,124.71 71.36,126.74 68.53,126.74 68.22,126.44 64.57,126.44 64.54,126.41 48.42,126.41 46.54,124.53 39.92,124.53 39.71,124.74 39.2,124.74 35.63,121.18 35.63,115.2 36.54,114.29 36.54,113.83 36.36,113.65 36.34,113.65 v2(36.09,113.4)
  BOTTOM w0.076: UC1.F16 v2(122.96,110.23)
PCIE_PRX_DTX_N6: length 124.2
  TOP w0.104: CT128.2 28.26,110.92 28.07,111.11 28.07,111.18 28.03,111.22 28.03,111.36 28.16,111.49 35.05,111.49 35.74,112.18 36.58,112.18 36.79,111.97 36.86,111.97 36.96,111.87 v2(36.96,111.8)
  IN3 w0.076: 121.39,111.58 121.42,111.55 121.42,109.87 121.61,109.69 121.81,109.69 v2(121.98,109.52)
  IN3 w0.135: v2(36.96,111.8) 37.05,111.8 37.38,112.12 37.38,112.45 37.67,112.74 37.67,114.14 36.35,115.47 36.35,120.8 38.96,123.42 47.18,123.42 48.89,125.13 65.44,125.13 65.87,125.56 69.45,125.56 69.54,125.47 70.39,125.47 72.09,123.77 80.72,123.77 83.6,126.65 85.71,126.65 86.37,127.32 89.58,127.32 90.26,128 100.63,128 101.37,127.27 103.7,127.27 105.59,125.37 116.06,125.37 117.73,123.7 117.73,119.7 119.89,117.55 119.89,117.04 121.39,115.54 121.39,111.59 121.39,111.58
  BOTTOM w0.076: v2(121.98,109.52) 122.21,109.52 UC1.G18
PCIE_PRX_DTX_N7: length 121.1
  TOP w0.104: v2(38.16,112.34) 38.26,112.44 38.45,112.44 38.56,112.34 38.56,111.88 38.22,111.54 37.28,111.54 36.78,111.05 30.59,111.05 30.37,110.83 30.37,110.64 30,110.27 CT9.2
  IN3 w0.076: v2(121.07,110.18) 120.94,110.18 120.52,110.6 120.52,111.53 120.5,111.56 120.5,111.58
  IN3 w0.135: 120.5,111.58 120.5,115.47 119.2,116.76 119.2,117.24 117.05,119.39 117.05,123.35 115.83,124.57 105.34,124.57 103.68,126.24 100.18,126.24 99.4,127.03 93.88,127.03 93.22,126.36 86.42,126.36 86.03,125.97 83.95,125.97 81.07,123.09 71.74,123.09 70.77,124.07 69.57,124.07 68.76,124.88 66.33,124.88 65.89,124.44 49.28,124.44 47.58,122.73 39.24,122.73 37.04,120.54 37.04,115.8 39,113.84 39,112.83 38.47,112.3 38.2,112.3 v2(38.16,112.34)
  BOTTOM w0.089: UC1.F20 121.36,109.94 121.12,110.18 v2(121.07,110.18)
PCIE_PRX_DTX_N8: length 118.4
  TOP w0.104: CT7.2 32.7,109.36 32.7,109.41 32.55,109.56 32.55,109.75 33,110.2 37.08,110.2 37.59,110.7 37.86,110.7 v2(38.23,110.34)
  IN3 w0.076: 119.28,111.32 119.28,111.31 119.32,111.31 119.6,111.03 119.6,111.02 119.61,111.01 119.61,110.01 119.79,109.84 120.02,109.84 120.23,109.62 v2(120.23,109.57)
  IN3 w0.135: v2(38.23,110.34) 38.29,110.34 38.46,110.51 38.46,110.51 39.68,111.74 39.68,114.25 37.86,116.08 37.86,119.98 39.25,121.37 47.21,121.37 49.59,123.75 66.24,123.75 66.59,124.1 68.48,124.1 69.83,122.75 71,122.75 71.67,122.08 72.33,122.08 72.52,121.89 81.73,121.89 82.59,122.75 82.59,123.56 83.84,124.82 91.07,124.82 91.88,125.63 93.58,125.63 93.95,125.99 95.52,125.99 96.04,125.48 103.4,125.48 106.13,122.75 110.01,122.75 110.27,123.01 115.89,123.01 116.37,122.52 116.37,119.06 118.52,116.91 118.52,116.03 118.87,115.68 118.87,111.88 118.87,111.54 119.07,111.34 119.23,111.34 119.25,111.32 119.28,111.32
  BOTTOM w0.076: UC1.G21 120.61,109.42 120.43,109.6 120.28,109.6 120.25,109.58 120.24,109.58 v2(120.23,109.57)
PCIE_PRX_DTX_N9: length 212.9
  TOP w0.104: CL2.1 240.15,127.67 239.95,127.67 239.62,127.34 v2(239.62,127.29)
  IN1 w0.119: v2(239.62,127.29) 239.6,127.32 239.6,127.63 239.72,127.76 240.11,127.76 240.31,127.57 240.31,123.52 239.53,122.74 238.35,122.74 234.79,119.18 234.79,113.41 234.57,113.19 234.57,102.02 234.86,101.74 234.86,96.78 234.27,96.2 234.27,79.56 232.31,77.6 232.31,74.36 228.99,71.04 228.99,68.8 226.31,66.11 222.62,66.11 222.19,66.55 195.99,66.55 arc(184.99,68.73) 175.66,74.96 174.93,75.69 arc(167.56,86.73) 164.97,99.75 164.97,104.94 154.55,115.36 146.7,115.36 143.94,118.11 140.08,118.11 138.34,116.38 129.73,116.38 128.75,115.4 127.3,115.4 126.81,115.9 124.8,115.9 124.35,115.44 123.1,115.44 122.72,115.06 122.72,114.32 119.56,111.16 119.56,110.69 119.44,110.57 119.24,110.57 119.12,110.69 119.12,110.89 v2(119.16,110.93)
  BOTTOM w0.102: UC1.E22 119.5,110.59 v2(119.16,110.93)
PCIE_PRX_DTX_N11: length 165.9
  IN3 w0.135: v2(21.79,49.96) 21.73,49.96 21.63,50.06 21.63,50.14 21.45,50.32 21.45,51.12 21.66,51.33 21.66,53.5 28.03,59.87 28.03,65.69 35.86,73.52 35.86,84.51 37.18,85.83 37.18,86.96 37.57,87.35 38.63,87.35 39.4,88.12 39.4,88.84 42.87,92.31 42.87,96.37 43.52,97.03 43.52,107.43 44.07,107.98 44.07,114.6 49.06,119.59 51.07,119.59 52.28,120.8 66.28,120.8 66.74,120.34 70,120.34 71.44,118.91 76.64,118.91 76.89,119.15 79.42,119.15 79.47,119.11 84.72,119.11 88.36,122.74 97.2,122.74 99.29,120.65 107.91,120.65 111.13,117.42 112.29,117.42 115.57,114.14 115.57,112.04 116.22,111.39 116.22,111.2 116.07,111.05 116.07,110.94 115.92,110.79 115.73,110.79 v2(115.63,110.89)
  BOTTOM w0.102: UC1.E28 116.04,110.72 115.86,110.89 v2(115.63,110.89)
  BOTTOM w0.104: v2(21.79,49.96) 21.52,49.69 21.52,49.36 21.84,49.03 21.84,44.88 21.95,44.77 JNGFF3.29
PCIE_PRX_DTX_N12: length 167
  IN3 w0.135: v2(114.64,110.84) 114.76,110.73 114.86,110.73 114.99,110.86 114.99,113.76 112.01,116.74 110.83,116.74 107.61,119.96 98.37,119.96 96.37,121.96 91.57,121.96 88.37,118.76 87.07,118.76 86.29,117.97 77.55,117.97 77.32,118.21 71.12,118.21 69.75,119.58 66.48,119.58 66.02,120.05 52.66,120.05 51.52,118.91 49.34,118.91 44.78,114.34 44.78,107.7 44.21,107.12 44.21,92.19 43.71,91.69 43.25,91.69 41.16,89.6 41.16,87.69 37.25,83.78 37.25,81.44 36.55,80.75 36.55,73.22 28.74,65.41 28.74,59.56 23.01,53.84 23.01,49.52 22.09,48.59 19.34,48.59 19.16,48.41 18.81,48.41 18.57,48.65 18.57,48.66 v2(18.4,48.83)
  BOTTOM w0.102: UC1.E30 115.09,110.56 114.84,110.56 114.64,110.76 v2(114.64,110.84)
  BOTTOM w0.104: JNGFF3.43 18.45,44.8 18.59,44.94 18.59,48.64 v2(18.4,48.83)
PCIE_PRX_DTX_P1: length 219.4
  TOP w0.104: v2(269.05,63.46) 269.24,63.27 269.66,63.27 CR13.1
  IN1 w0.119: v2(269.05,63.46) 269,63.46 268.63,63.09 268.28,63.09 267.84,63.54 267.84,66.85 270.05,69.06 270.05,72.76 268.26,74.55 263.33,74.55 262.63,73.85 259.61,73.85 258.89,73.13 256.91,73.13 255.12,71.34 251.3,71.34 249.41,69.45 245.51,69.45 244.57,68.51 234.08,68.51 232.34,66.78 232.34,63.89 229.98,61.53 227.13,61.53 226.47,62.2 219.33,62.2 218.97,61.84 215.68,61.84 214.88,62.63 181.72,62.63 180.9,63.46 180.9,64.12 175.47,69.55 174.12,69.55 171.88,71.78 163.59,71.78 162.97,71.16 151.99,71.16 151.05,72.1 151.05,82.56 152.35,83.85 152.35,86.93 154.47,89.05 154.47,94.84 155.11,95.48 155.11,100.28 154.62,100.77 154.62,104.66 152.8,106.48 152.8,109.42 151.02,111.2 147.53,111.2 145.95,109.61 140.38,109.61 138.14,111.86 138.14,112.7 137.23,113.6 133.15,113.6 132,112.46 126.84,112.46 126.42,112.04 126.42,110.87 125.92,110.36 125.92,109.56 125.82,109.46 125.69,109.46 v2(125.65,109.5)
  BOTTOM w0.076: UC1.G13 125.44,109.29 v2(125.65,109.5)
PCIE_PRX_DTX_P3: length 148.8
  IN1 w0.119: v2(232.24,70.68) 232.1,70.55 231.75,70.55 231.53,70.33 231.53,69.21 227.14,64.82 221.78,64.82 221.34,65.26 195.88,65.26 arc(184.43,67.54) 174.72,74.02 173.99,74.75 arc(166.33,86.22) 163.64,99.75 163.64,103.24 160.4,106.48 160.4,106.94 159.43,107.91 159.01,107.91 157.8,109.12 157.44,109.12 155.59,110.97 153.64,110.97 151.3,113.31 146.87,113.31 143.36,116.83 140.64,116.83 138.91,115.09 131.38,115.09 130.45,114.17 130.45,113.9 130.25,113.69 125.18,113.69 123.38,111.89 123.38,109.41 123.28,109.3 123.07,109.3 122.93,109.43 122.93,109.55 v2(122.98,109.6)
  BOTTOM w0.076: UC1.G16 123.29,109.29 122.98,109.6 v2(122.98,109.6)
  BOTTOM w0.104: v2(232.24,70.68) 232.24,70.68 232.43,70.49 232.56,70.49 232.72,70.65 JNGFF1.41
PCIE_PRX_DTX_P4: length 145.2
  IN1 w0.119: v2(124.63,109.63) 124.63,109.47 124.77,109.33 124.94,109.33 125.04,109.43 125.04,109.75 125.12,109.82 125.12,112.41 125.83,113.12 132,113.12 132.44,113.56 132.44,113.84 132.64,114.04 132.64,114.26 132.83,114.45 137.38,114.45 138.8,113.03 138.8,112.16 140.65,110.31 145.25,110.31 147.53,112.6 151.1,112.6 153.43,110.27 155.17,110.27 158.18,107.26 159.16,107.26 159.6,106.82 159.6,106.33 162.95,102.98 162.95,99.75 162.96,99.75 arc(165.7,85.96) 173.51,74.27 174.24,73.54 arc(174.58,73.19) 174.94,72.86 arc(184.58,66.75) 195.78,64.62 220.91,64.62 221.36,64.17 227.46,64.17 227.84,64.55 227.84,64.55 227.95,64.66 229.04,64.66 v2(229.07,64.64)
  BOTTOM w0.076: UC1.F15 124.62,109.69 124.63,109.63 v2(124.63,109.63)
  BOTTOM w0.104: JNGFF1.65 232.6,64.65 232.42,64.47 230.92,64.47 230.89,64.5 230.28,64.5 230.25,64.47 229.23,64.47 v2(229.07,64.64)
PCIE_PRX_DTX_P5: length 129.5
  TOP w0.104: CT129.2 25.74,111.69 26.02,111.97 27.37,111.97 27.75,112.35 34.68,112.35 35.14,112.82 35.14,113.68 35.47,114.01 v2(36.12,114.01)
  IN3 w0.076: 122.85,111.58 122.83,111.56 122.83,111.26 122.53,110.96 122.53,110.6 122.61,110.53 122.76,110.53 122.82,110.58 122.93,110.58 123.01,110.66 123.01,110.83 v2(122.96,110.88)
  IN3 w0.135: v2(36.12,114.01) 36.19,114.08 36.19,114.3 35.39,115.1 35.39,121.28 39.1,124.98 39.81,124.98 40.02,124.78 46.44,124.78 48.32,126.66 64.1,126.66 64.12,126.68 68.12,126.68 68.43,126.99 71.46,126.99 73.49,124.96 74.12,124.96 74.47,125.3 75.23,125.3 75.83,124.69 80.32,124.69 83.2,127.58 85.29,127.58 85.98,128.27 89.21,128.27 90.4,129.46 100.78,129.46 102.02,128.22 104.23,128.22 105.57,126.88 116.49,126.88 117.8,125.58 119.42,125.58 120.8,124.2 120.8,118.93 121.24,118.49 121.24,116.99 122.87,115.36 122.87,111.6 122.85,111.58
  BOTTOM w0.076: UC1.E16 v2(122.96,110.88)
PCIE_PRX_DTX_P6: length 124.3
  TOP w0.104: v2(36.96,112.38) 35.66,112.38 34.97,111.69 28.08,111.69 27.71,111.33 CT127.2
  IN3 w0.076: 121.63,111.58 121.63,111.57 121.61,111.55 121.61,109.95 121.68,109.87 121.94,109.87 122.06,109.99 122.06,110.1 v2(121.98,110.18)
  IN3 w0.135: v2(36.96,112.38) 36.97,112.38 37.43,112.84 37.43,114.04 36.1,115.37 36.1,120.9 38.86,123.66 47.08,123.66 48.79,125.37 65.34,125.37 65.77,125.8 69.55,125.8 69.64,125.71 70.49,125.71 72.19,124.01 80.62,124.01 83.5,126.9 85.61,126.9 86.27,127.56 89.48,127.56 90.16,128.24 100.73,128.24 101.47,127.51 103.8,127.51 105.69,125.61 116.16,125.61 117.98,123.8 117.98,119.8 120.13,117.65 120.13,117.14 121.63,115.64 121.63,111.58
  BOTTOM w0.076: v2(121.98,110.18) 122.22,109.94 UC1.F18
PCIE_PRX_DTX_P7: length 121.1
  TOP w0.104: CT8.2 30.57,110.74 30.67,110.85 36.87,110.85 37.36,111.34 38.3,111.34 38.76,111.8 38.76,112.42 38.51,112.67 38.43,112.85 v2(38.43,112.86)
  IN3 w0.076: v2(121.07,110.96) 121.07,110.61 120.99,110.53 120.84,110.53 120.7,110.68 120.7,111.53 120.73,111.56 120.73,111.58
  IN3 w0.135: 120.73,111.58 120.73,115.57 119.44,116.86 119.44,117.34 117.29,119.49 117.29,123.45 115.93,124.81 105.44,124.81 103.78,126.48 100.28,126.48 99.5,127.27 93.78,127.27 93.12,126.6 86.32,126.6 85.93,126.21 83.85,126.21 80.97,123.33 71.84,123.33 70.87,124.31 69.67,124.31 68.86,125.12 66.23,125.12 65.79,124.68 49.18,124.68 47.48,122.98 39.14,122.98 36.8,120.64 36.8,115.7 38.76,113.74 38.76,112.99 38.63,112.86 v2(38.43,112.86)
  BOTTOM w0.089: v2(121.07,110.96) 121.11,110.96 121.47,110.59 UC1.E20
PCIE_PRX_DTX_P8: length 118.4
  TOP w0.104: CT6.2 32.35,109.83 32.91,110.4 37,110.4 37.53,110.93 v2(38.23,110.93)
  IN3 w0.076: 119.28,111.58 119.32,111.58 119.49,111.41 119.49,111.41 119.79,111.11 119.79,111.1 119.8,111.09 119.8,110.09 119.87,110.02 120.09,110.02 120.17,110.09 v2(120.17,110.25)
  IN3 w0.135: 119.28,111.58 119.17,111.58 119.11,111.64 119.11,111.78 119.11,115.78 118.76,116.13 118.76,117.01 116.61,119.16 116.61,122.62 115.99,123.25 110.17,123.25 109.91,122.99 106.23,122.99 103.5,125.72 96.14,125.72 95.62,126.24 93.85,126.24 93.48,125.87 91.78,125.87 90.97,125.06 83.74,125.06 82.34,123.66 82.34,122.85 81.63,122.13 72.62,122.13 72.43,122.32 71.77,122.32 71.1,122.99 69.93,122.99 68.58,124.34 66.49,124.34 66.14,123.99 49.49,123.99 47.11,121.61 39.15,121.61 37.62,120.08 37.62,115.98 39.44,114.15 39.44,111.84 38.48,110.87 38.29,110.87 v2(38.23,110.93)
  BOTTOM w0.076: v2(120.17,110.25) 120.17,110.19 120.42,109.94 UC1.F21
PCIE_PRX_DTX_P9: length 212.9
  TOP w0.104: CL1.1 240.36,128.31 240.01,127.95 239.86,127.95 v2(239.62,128.19)
  IN1 w0.119: v2(239.62,128.19) 239.83,127.98 240.2,127.98 240.52,127.66 240.52,123.43 239.62,122.53 238.44,122.53 235,119.09 235,113.32 234.79,113.1 234.79,102.11 235.08,101.83 235.08,96.69 234.49,96.11 234.49,79.47 232.53,77.51 232.53,74.27 229.21,70.95 229.21,68.71 226.4,65.9 222.53,65.9 222.09,66.33 195.99,66.33 arc(184.91,68.53) 175.51,74.81 174.78,75.54 arc(167.36,86.65) 164.75,99.75 164.75,104.84 154.46,115.14 146.61,115.14 143.85,117.89 140.17,117.89 138.43,116.16 129.82,116.16 128.84,115.18 127.21,115.18 126.72,115.68 124.89,115.68 124.44,115.23 123.19,115.23 122.93,114.97 122.93,114.23 119.78,111.07 119.78,110.6 119.36,110.18 v2(119.24,110.18)
  BOTTOM w0.102: UC1.E23 118.83,110.59 v2(119.24,110.18)
PCIE_PRX_DTX_P11: length 166
  IN3 w0.135: v2(21.21,49.96) 21.21,51.22 21.42,51.43 21.42,53.6 27.79,59.97 27.79,65.79 35.62,73.62 35.62,84.61 36.94,85.93 36.94,87.06 37.47,87.59 38.53,87.59 39.16,88.22 39.16,88.94 42.63,92.41 42.63,96.47 43.28,97.13 43.28,107.53 43.83,108.08 43.83,114.7 48.96,119.83 50.97,119.83 52.18,121.04 66.38,121.04 66.84,120.58 70.1,120.58 71.54,119.15 76.54,119.15 76.79,119.39 79.52,119.39 79.57,119.35 84.62,119.35 88.26,122.98 97.3,122.98 99.39,120.89 108.01,120.89 111.23,117.66 112.39,117.66 115.81,114.24 115.81,112.14 116.46,111.49 v2(116.46,110.88)
  BOTTOM w0.102: UC1.E27 116.67,110.88 v2(116.46,110.88)
  BOTTOM w0.104: v2(21.21,49.96) 21.32,49.85 21.32,49.27 21.64,48.95 21.64,44.87 21.45,44.68 JNGFF3.31
PCIE_PRX_DTX_P12: length 166.9
  IN3 w0.135: v2(18.98,48.83) 21.99,48.83 22.77,49.62 22.77,53.94 28.5,59.66 28.5,65.51 36.31,73.32 36.31,80.85 37.01,81.54 37.01,83.88 40.92,87.79 40.92,89.7 43.15,91.93 43.61,91.93 43.97,92.29 43.97,107.22 44.54,107.8 44.54,114.44 49.24,119.15 51.42,119.15 52.56,120.29 66.12,120.29 66.58,119.82 69.85,119.82 71.22,118.45 77.42,118.45 77.65,118.22 86.19,118.22 86.97,119 88.27,119 91.47,122.2 96.47,122.2 98.47,120.2 107.71,120.2 110.93,116.98 112.11,116.98 115.23,113.86 115.23,110.76 114.68,110.2 v2(114.67,110.2)
  BOTTOM w0.102: UC1.F30 114.93,109.94 v2(114.67,110.2)
  BOTTOM w0.104: JNGFF3.41 18.95,44.79 18.79,44.95 18.79,48.64 v2(18.98,48.83)
PCIE_PTX_C_DRX_N1: length 2.7
  TOP w0.104: CR12.2 271.35,65.67 271.6,65.67 272.11,65.17 272.71,65.17 272.81,65.07 UR1.4
PCIE_PTX_C_DRX_N3: length 2.7
  BOTTOM w0.104: JNGFF1.37 232.61,71.65 232.45,71.82 231.24,71.82 CZ13.2
PCIE_PTX_C_DRX_N4: length 2.8
  BOTTOM w0.104: JNGFF1.61 232.53,65.65 232.37,65.81 231.13,65.81 CZ15.2
PCIE_PTX_C_DRX_N5: length 2.8
  TOP w0.076: UT1.H22 27.75,106.44 27.75,106.87 27.6,107.01 27.6,107.51 27.48,107.63
  TOP w0.104: CT126.2 27.08,108.37 27.08,108.04 27.48,107.63
PCIE_PTX_C_DRX_N6: length 2.7
  TOP w0.076: 29.49,107.57 29.49,106.97 29.59,106.87 29.59,106.44 UT1.M22
  TOP w0.104: CT124.2 29.18,108.38 29.18,107.87 29.49,107.57
PCIE_PTX_C_DRX_N7: length 2.6
  TOP w0.076: 31.46,107.54 31.43,107.51 31.43,106.44 UT1.T22
  TOP w0.104: 31.46,107.54 31.59,107.67 31.59,108.37 CT5.2
PCIE_PTX_C_DRX_N8: length 2.8
  TOP w0.076: 33.85,107.94 33.85,107.93 33.84,107.92 33.84,107.65 33.27,107.08 33.27,106.46 33.04,106.23 UT1.Y22
  TOP w0.104: CT3.2 33.85,108.35 33.85,107.94
PCIE_PTX_C_DRX_N9: length 2.3
  TOP w0.104: CL6.2 241.63,125.97 241.96,125.97 242.23,126.23 242.55,126.23 242.65,126.13 UL1.42
PCIE_PTX_C_DRX_N11: length 3.9
  BOTTOM w0.104: JNGFF3.35 20.45,44.62 20.29,44.78 20.29,45.07 20.57,45.35 20.57,46.1 20.6,46.13 20.6,46.7 20.57,46.73 20.57,47.04 CN69.1
PCIE_PTX_C_DRX_N12: length 3.9
  BOTTOM w0.104: JNGFF3.47 17.45,44.61 17.3,44.76 17.3,45.29 17.02,45.57 17.02,46.11 17.04,46.14 17.04,46.72 17.02,46.75 17.02,47.04 CN71.1
PCIE_PTX_C_DRX_P1: length 2.7
  TOP w0.104: CR11.2 271.35,65.87 271.73,65.87 v4(272,65.6) 272.23,65.37 272.72,65.37 272.82,65.47 UR1.3
PCIE_PTX_C_DRX_P3: length 2.7
  BOTTOM w0.104: CZ12.2 231.19,72.02 232.47,72.02 232.6,72.15 JNGFF1.35
PCIE_PTX_C_DRX_P4: length 2.8
  BOTTOM w0.104: JNGFF1.59 232.48,66.15 232.34,66.01 231.15,66.01 CZ14.2
PCIE_PTX_C_DRX_P5: length 2.7
  TOP w0.076: UT1.H23 27.52,106.56 27.47,106.51 27.38,106.51 27.29,106.59 27.29,106.85 27.43,106.99 27.43,107.4 27.34,107.49
  TOP w0.104: 27.34,107.49 26.87,107.95 26.87,108.38 CT125.2
PCIE_PTX_C_DRX_P6: length 2.6
  TOP w0.076: 29.28,107.48 29.28,107 29.13,106.85 29.13,106.59 29.22,106.51 29.31,106.51 29.36,106.56 UT1.M23
  TOP w0.104: 29.28,107.48 28.98,107.78 28.98,108.36 CT123.2
PCIE_PTX_C_DRX_P7: length 2.6
  TOP w0.076: UT1.T23 31.2,106.56 31.15,106.51 31.06,106.51 30.97,106.59 30.97,106.85 31.23,107.11 31.25,107.13 31.25,107.62 31.32,107.68
  TOP w0.104: 31.32,107.68 31.39,107.75 31.39,108.37 CT4.2
PCIE_PTX_C_DRX_P8: length 2.9
  TOP w0.076: UT1.Y23 33.04,106.54 32.99,106.48 32.89,106.48 32.81,106.56 32.81,106.86 33.67,107.72 33.67,107.92 33.65,107.94
  TOP w0.104: CT2.2 33.65,108.4 33.65,107.94
PCIE_PTX_C_DRX_P9: length 2.3
  TOP w0.104: UL1.41 242.65,126.53 242.55,126.43 242.14,126.43 241.88,126.17 241.61,126.17 CL5.2
PCIE_PTX_C_DRX_P11: length 3.8
  BOTTOM w0.104: CN70.1 20.37,47.04 v4(20.37,46.42) 20.37,45.43 20.09,45.15 20.09,44.77 19.95,44.63 JNGFF3.37
PCIE_PTX_C_DRX_P12: length 3.9
  BOTTOM w0.104: CN72.1 16.81,47.04 v4(16.81,46.42) 16.81,45.5 17.1,45.21 17.1,44.75 16.95,44.6 JNGFF3.49
PCIE_PTX_DRX_N1: length 199.2
  TOP w0.104: CR12.1 269.59,65.75 269.22,65.75 v2(269.03,65.56)
  IN1 w0.119: v2(269.03,65.56) 268.88,65.71 268.5,65.71 268.28,65.92 268.28,66.69 270.47,68.88 270.47,72.94 268.44,74.97 266.04,74.97 264.94,76.07 262.53,76.07 261.15,74.7 258.48,74.7 258.05,74.26 255.9,74.26 253.83,72.19 250.94,72.19 249.58,70.83 245.51,70.83 244.05,69.36 234.15,69.36 232.16,71.35 231.52,71.35 231.1,70.93 231.1,69.43 226.92,65.24 222.06,65.24 221.62,65.69 195.95,65.69 arc(184.63,67.93) 175.04,74.34 174.31,75.07 arc(166.75,86.4) 164.09,99.75 164.09,104.48 161.2,107.37 160.78,107.37 155.38,112.77 152.67,112.77 150.96,114.48 146.32,114.48 143.55,117.25 140.45,117.25 138.72,115.52 131.2,115.52 129.9,114.22 124.75,114.22 124.57,114.4 123.97,114.4 v2(123.77,114.19)
  BOTTOM w0.076: UC1.B17 123.04,112.89 123.09,112.89 123.14,112.94 123.26,113.06 123.26,113.45 123.22,113.55 123.22,114.35 123.35,114.48 123.53,114.48 123.77,114.24 v2(123.77,114.19)
PCIE_PTX_DRX_N3: length 147.4
  IN3 w0.135: v2(123.66,116.27) 123.84,116.27 124.01,116.44 124.26,116.44 124.44,116.62 126.62,116.62 127.07,116.17 129.27,116.17 129.78,116.67 139,116.67 139.91,117.59 143.82,117.59 145.98,115.43 148.61,115.43 153.4,110.64 156.3,110.64 158.93,108.01 160.88,108.01 164.68,104.21 164.68,99.42 arc(167.25,86.54) 174.55,75.61 175.54,74.61 arc(184.66,68.52) 195.41,66.38 203.66,66.38 204.59,65.46 220.7,65.46 223.29,68.04 226.01,68.04 228.58,70.62 228.67,70.62 229.7,71.65 229.7,71.84 229.55,72 229.41,72 229.23,71.82 229.07,71.82 228.98,71.73 v2(228.98,71.62)
  BOTTOM w0.076: UC1.D17 122.59,111.69 122.53,111.91 122.53,112.03 122.38,112.55 122.38,112.8 122.38,112.8 122.41,112.9 122.41,113.09 122.38,113.14 122.38,113.65 122.51,113.77 122.51,114.59 123.67,115.75 123.67,116.26 v2(123.66,116.27)
  BOTTOM w0.104: CZ13.1 229.58,71.82 229.19,71.82 v2(228.98,71.62)
PCIE_PTX_DRX_N4: length 155.4
  IN3 w0.135: v2(224.64,71.08) 224.64,71.07 224.98,70.72 224.98,70.43 224.07,69.52 222.73,69.52 220.09,66.87 205.28,66.87 204.41,67.74 195.57,67.74 arc(185.19,69.81) 176.39,75.69 175.51,76.57 arc(168.5,87.06) 166.04,99.43 166.04,105.63 160.97,110.7 159.27,110.7 153.3,116.67 153.3,118.14 149.07,122.36 138.17,122.36 137.57,122.96 133.95,122.96 132.05,121.07 128.51,121.07 126.31,118.87 124.42,118.87 124.13,118.58 124.13,118.35 123.52,117.75 122.88,117.75 v2(122.49,118.13)
  BOTTOM w0.076: UC1.B19 121.09,113.32 121.09,115.06 121.49,115.46 121.49,117.49 121.55,117.55 121.55,117.61
  BOTTOM w0.104: 121.55,117.61 121.55,117.95 121.73,118.13 v2(122.49,118.13) ; CZ15.1 229.69,65.67 228.29,65.67 224.64,69.32 v2(224.64,71.08)
PCIE_PTX_DRX_N5: length 131.2
  TOP w0.104: CT126.1 27.07,109.34 27.07,109.56 v2(27.27,109.76)
  IN1 w0.119: v2(119.24,123.54) 119.3,123.48 119.47,123.48 119.6,123.61 119.6,123.73 119.8,123.93 119.8,124.43 119.24,124.99 119.24,127.07 116.05,130.26 109.12,130.26 106.58,132.79 83.47,132.79 79.41,128.73 46.75,128.73 45.78,127.76 36.89,127.76 35.54,126.41 31.25,126.41 27.8,122.96 27.8,112.18 26.73,111.11 26.73,110.21 26.77,110.17 26.86,110.17 27.1,109.93 27.1,109.84 27.18,109.76 v2(27.27,109.76)
  BOTTOM w0.076: 123,117.61 123,117.6 123.02,117.59 123.02,117.45 123.03,116.83 121.83,115.63 121.83,115.32 121.6,115.09 121.6,114.14 121.8,113.95 121.8,113.37 121.71,113.17 121.71,112.76 121.72,112.73 121.72,112.52 121.61,112.33 121.61,112.33 121.45,112.33 121.38,112.27 121.38,112.09 UC1.C19
  BOTTOM w0.104: v2(119.24,123.54) 119.45,123.54 119.84,123.15 120.19,123.15 121.49,121.85 121.49,119.77 123,118.26 123,117.61
PCIE_PTX_DRX_N6: length 130
  TOP w0.104: CT124.1 29.36,109.19 29.04,109.51 29.04,109.69 29.17,109.82 29.32,109.82 v2(29.37,109.76)
  IN1 w0.119: v2(120.14,122.41) 119.5,123.05 119.26,123.05 119.26,123.06 118.64,123.06 118.24,123.46 118.24,126.22 114.67,129.79 108.9,129.79 107.09,131.6 82.88,131.6 79.57,128.29 47.28,128.29 45.9,126.91 36.85,126.91 35.91,125.97 31.46,125.97 28.24,122.75 28.24,111.37 27.79,110.92 27.79,109.02 28.03,108.77 29.12,108.77 29.37,109.02 29.37,109.68 29.37,109.69 v2(29.37,109.76)
  BOTTOM w0.076: 121.14,117.61 121.14,117.53 121.12,117.52 121.12,116.86 120.92,116.66 120.92,113.15 121.09,112.98 121.17,112.83 121.17,112.21 120.89,111.94 UC1.D20
  BOTTOM w0.104: 121.14,117.61 121.14,119.27 120.99,119.42 v4(120.99,120.47) 120.99,121.56 v2(120.14,122.41)
PCIE_PTX_DRX_N7: length 124.4
  TOP w0.104: v2(31.78,109.76) 31.58,109.56 31.58,109.34 CT5.1
  IN1 w0.119: v2(31.78,109.76) 31.61,109.93 31.61,110.47 31.36,110.72 29.63,110.72 29.13,111.21 29.13,121.95 31.84,124.66 36.1,124.66 36.94,125.5 46.13,125.5 48.04,127.41 79.91,127.41 83.21,130.71 104.15,130.71 105.96,128.9 112.85,128.9 115.01,126.73 116.5,126.73 117.36,125.86 117.36,122.78 118.8,121.35 v2(119.54,121.35)
  BOTTOM w0.076: UC1.B21 120.33,112.91 120.59,113.17 120.59,116.26 119.84,117.01 119.84,117.58 119.86,117.59 119.86,117.61
  BOTTOM w0.104: v2(119.54,121.35) 120.33,120.56 120.33,119.05 119.86,118.58 v4(119.86,118.11) 119.86,117.61
PCIE_PTX_DRX_N8: length 120.1
  TOP w0.104: CT3.1 33.87,109.34 33.87,109.56 v2(34.07,109.76)
  IN1 w0.119: v2(34.07,109.76) 34.05,109.76 33.84,109.97 33.84,109.99 33.65,110.17 33.38,110.17 30.4,113.15 30.4,118.02 37.15,124.76 46.6,124.76 48.56,126.72 80.13,126.72 83.47,130.07 103.87,130.07 105.98,127.96 109.45,127.96 112.75,124.66 116.23,124.66 116.7,124.19 116.7,121.48 118.17,120.01 118.6,120.01 v2(118.85,119.76)
  BOTTOM w0.076: 118.95,117.61 118.95,117.59 118.96,117.58 118.96,116.99 120.06,115.89 120.06,113.76 119.9,113.59 119.9,113.18 119.93,113.08 119.93,112.89 119.9,112.8 119.9,112.55 120.02,112.13 120.04,112.07 120.04,111.96 120.11,111.69 UC1.D21
  BOTTOM w0.104: v2(118.85,119.76) 119.11,120.02 119.26,120.02 119.45,119.83 119.45,119.35 118.95,118.85 118.95,117.61
PCIE_PTX_DRX_N9: length 213.6
  TOP w0.104: v2(239.42,125.4) 239.39,125.4 239.07,125.72 239.07,125.88 239.23,126.04 240.1,126.04 240.36,125.78 CL6.1
  IN1 w0.119: v2(239.42,125.4) 239.42,123.95 238.7,123.22 235.7,123.22 234.29,121.82 234.29,113.75 234.15,113.6 234.15,102.09 233.78,101.73 233.78,94.81 231.69,92.71 231.69,82.96 228.13,79.4 228.13,78.29 227.07,77.24 227.07,74.12 228.57,72.62 228.57,69.93 226.89,68.26 196.12,68.26 arc(185.72,70.32) 176.91,76.21 176.18,76.94 arc(169.19,87.41) 166.73,99.75 166.73,104.42 159.91,111.24 159.91,113.66 156.44,117.14 155.08,117.14 153.26,118.96 147.3,118.96 146.43,119.83 139.31,119.83 137.64,118.16 132.3,118.16 131.87,118.59 122.36,118.59 122.06,118.29 122.06,117.09 121.27,116.3 119.16,116.3 118.85,115.99 v2(118.06,115.99)
  BOTTOM w0.076: v2(118.06,115.99) 118.19,115.99 118.55,115.63 118.55,113.34 118.98,112.91 UC1.B23
PCIE_PTX_DRX_N11: length 165.9
  IN3 w0.135: v2(20.45,49.97) 20.35,49.97 20.28,50.05 20.28,50.14 20.1,50.32 20.1,50.74 20.9,51.53 20.9,53.84 27.34,60.29 27.34,65.99 35.17,73.81 35.17,85.37 35.71,85.92 35.71,86.83 36.25,87.37 36.62,87.37 37.87,88.63 37.87,89.4 38.34,89.86 39.43,89.86 42.16,92.59 42.16,97.89 42.77,98.5 42.77,107.71 43.38,108.32 43.38,114.87 48.78,120.27 49.71,120.27 50.98,121.54 66.56,121.54 67.04,121.05 70.33,121.05 71.14,120.25 79.34,120.25 79.8,119.79 83.18,119.79 86.84,123.45 103.02,123.45 105.08,121.38 108.14,121.38 111.38,118.15 114.55,118.15 115.77,116.93 115.77,115.29 116.25,114.82 117.7,114.82 118.05,114.47 v2(118.06,114.47)
  BOTTOM w0.076: UC1.D24 118.42,111.93 118.7,112.21 118.7,112.52 118.3,112.92 118.3,113.63 117.68,114.25 117.68,114.51 117.81,114.65 117.92,114.65 118.06,114.51 v2(118.06,114.47)
  BOTTOM w0.104: CN69.2 20.57,48.64 20.57,49.04 20.25,49.35 20.25,49.78 20.27,49.79 20.27,49.8 v2(20.45,49.97)
PCIE_PTX_DRX_N12: length 172.8
  IN3 w0.135: v2(17.3,49.48) 17.3,49.67 17.4,49.77 17.46,49.77 17.65,49.95 18.35,49.95 20.22,51.81 20.22,54.18 26.62,60.58 26.62,66.66 27.05,67.09 27.05,74.79 27.91,75.65 29.52,75.65 32.24,78.37 33.33,78.37 34,79.03 34,85.61 34.95,86.57 34.95,87.93 37.58,90.56 39.12,90.56 41.41,92.85 41.41,98.16 41.72,98.46 41.72,99.95 41.3,100.37 41.3,101.41 42.09,102.2 42.09,108.44 41.5,109.03 41.5,111.81 42.67,112.98 42.67,115.13 47.83,120.28 47.83,120.94 49.83,122.94 59.65,122.94 60.13,122.45 68.99,122.45 69.6,121.84 70.56,121.84 71.46,120.95 81.96,120.95 85.15,124.14 91.46,124.14 92.22,124.89 93.86,124.89 94.62,124.13 103.37,124.13 105.44,122.07 108.46,122.07 111.65,118.87 115.6,118.87 117.4,117.07 117.4,116.17 117.17,115.95 117,115.95 116.86,116.09 116.86,116.41 116.8,116.47 116.61,116.47 116.48,116.34 v2(116.44,116.34)
  BOTTOM w0.076: v2(116.44,116.34) 116.44,116.26 116.7,116 116.81,116 117.19,115.63 117.19,114.14 117.58,113.75 117.58,113.24 117.65,113.17 117.78,113.17 117.85,113.25 UC1.A25
  BOTTOM w0.104: v2(17.3,49.48) 17.3,49.59 17.19,49.69 16.78,49.69 16.67,49.59 16.67,48.98 CN71.2
PCIE_PTX_DRX_P1: length 199.2
  TOP w0.104: CR11.1 269.75,65.95 269.22,65.95 v2(269.03,66.14)
  IN1 w0.119: v2(269.03,66.14) 268.82,65.93 268.59,65.93 268.5,66.01 268.5,66.6 270.69,68.79 270.69,73.03 268.53,75.19 266.14,75.19 265.04,76.29 262.44,76.29 261.06,74.92 258.39,74.92 257.96,74.48 255.81,74.48 253.74,72.41 250.85,72.41 249.49,71.05 245.42,71.05 243.95,69.58 234.24,69.58 232.25,71.57 231.43,71.57 230.88,71.02 230.88,69.52 226.82,65.46 222.15,65.46 221.71,65.9 195.95,65.9 arc(184.72,68.14) 175.2,74.5 174.47,75.23 arc(166.95,86.48) 164.31,99.75 164.31,104.57 161.29,107.59 160.87,107.59 155.47,112.99 152.76,112.99 151.05,114.7 146.41,114.7 143.64,117.47 140.36,117.47 138.63,115.74 131.11,115.74 129.81,114.44 124.84,114.44 124.66,114.62 123.92,114.62 v2(123.77,114.77)
  BOTTOM w0.076: UC1.A17 122.81,113.12 122.87,113.06 123.02,113.06 123.09,113.13 123.09,113.42 123.04,113.51 123.04,114.42 123.29,114.66 123.66,114.66 123.77,114.77 v2(123.77,114.77)
PCIE_PTX_DRX_P3: length 147.4
  IN3 w0.135: v2(228.98,72.24) 229.65,72.24 229.94,71.94 229.94,71.55 228.77,70.38 228.68,70.38 226.11,67.8 223.39,67.8 220.8,65.22 204.49,65.22 203.56,66.14 195.41,66.14 arc(184.57,68.3) 175.37,74.44 174.38,75.44 arc(167.02,86.44) 164.44,99.42 164.44,104.11 160.78,107.77 158.82,107.77 156.2,110.4 153.3,110.4 148.51,115.19 145.88,115.19 143.72,117.35 140.01,117.35 139.1,116.43 129.88,116.43 129.37,115.92 126.97,115.92 126.52,116.38 124.54,116.38 v2(124.18,116.02)
  BOTTOM w0.076: UC1.C17 122.81,111.95 122.88,111.87 123.01,111.87 123.1,111.96 123.1,112.21 122.98,112.32 122.69,112.32 122.6,112.42 122.54,112.58 122.54,112.75 122.58,112.87 122.58,113.13 122.55,113.18 122.55,113.57 122.68,113.7 122.68,114.52 v2(124.18,116.02)
  BOTTOM w0.104: CZ12.1 229.65,72.03 229.19,72.03 v2(228.98,72.24)
PCIE_PTX_DRX_P4: length 155.4
  IN3 w0.135: v2(225.22,71.08) 225.19,71.05 225.19,70.86 225.22,70.82 225.22,70.33 224.17,69.28 222.83,69.28 220.19,66.63 205.18,66.63 204.31,67.5 195.57,67.5 arc(185.1,69.58) 176.22,75.52 175.34,76.4 arc(168.28,86.97) 165.8,99.43 165.8,105.53 160.87,110.46 159.17,110.46 153.06,116.57 153.06,118.04 148.97,122.12 138.07,122.12 137.47,122.72 134.05,122.72 132.15,120.83 128.61,120.83 126.41,118.63 124.52,118.63 124.37,118.48 124.37,118.25 123.62,117.5 v2(122.49,117.5)
  BOTTOM w0.076: UC1.A19 121.34,113.31 121.26,113.39 121.26,113.55 121.34,113.63 121.56,113.63 121.64,113.7 121.64,113.88 121.54,113.97 121.35,113.97 121.26,114.06 121.26,114.98 121.66,115.39 121.66,117.37 121.75,117.45
  BOTTOM w0.104: v2(122.49,117.5) 122.29,117.5 122.19,117.61 122.19,117.8 122.06,117.93 121.86,117.93 121.75,117.82 121.75,117.45 ; v2(225.22,71.08) 224.84,70.7 224.84,69.41 228.37,65.87 229.38,65.87 CZ14.1
PCIE_PTX_DRX_P5: length 131.2
  TOP w0.104: v2(26.69,109.76) 26.87,109.57 26.87,109.32 CT125.1
  IN1 w0.119: v2(120.01,123.56) 120.01,124.52 119.45,125.08 119.45,127.16 116.14,130.48 109.21,130.48 106.67,133.01 83.38,133.01 79.31,128.94 46.66,128.94 45.69,127.97 36.8,127.97 35.45,126.63 31.16,126.63 27.58,123.05 27.58,112.27 26.51,111.2 26.51,109.94 v2(26.69,109.76)
  BOTTOM w0.076: 123.2,117.61 123.2,117.6 123.19,117.59 123.19,117.46 123.2,116.76 122,115.56 122,115.25 121.78,115.02 121.78,114.21 121.97,114.02 121.97,113.33 121.88,113.13 121.88,112.78 121.89,112.75 121.89,112.47 121.79,112.29 121.78,111.85 UC1.D19
  BOTTOM w0.104: 123.2,117.61 123.2,118.34 121.69,119.86 121.69,121.94 120.07,123.56 v2(120.01,123.56)
PCIE_PTX_DRX_P6: length 129.9
  TOP w0.104: v2(28.93,110.15) 28.79,110.01 CT123.1
  IN1 w0.119: v2(119.71,121.91) 119.84,122.03 119.84,122.13 119.72,122.24 119.72,122.52 119.41,122.84 119.17,122.84 119.17,122.84 118.55,122.84 118.02,123.37 118.02,126.13 114.58,129.57 108.81,129.57 107,131.38 82.97,131.38 79.66,128.08 47.37,128.08 45.99,126.69 36.94,126.69 36.01,125.75 31.55,125.75 28.46,122.66 28.46,111.28 28,110.83 28,109.11 28.12,108.99 29.03,108.99 29.15,109.11 29.15,109.4 29.09,109.46 28.92,109.46 28.66,109.72 28.66,110.03 28.78,110.15 v2(28.93,110.15)
  BOTTOM w0.076: 120.94,117.61 120.94,117.6 120.95,117.59 120.95,116.93 120.75,116.73 120.75,112.96 120.83,112.89 120.94,112.89 120.95,112.87 121,112.79 121,112.69 120.93,112.63 120.62,112.63 120.58,112.6 120.58,112.49 120.56,112.47 120.56,112.4 120.71,112.24 120.82,112.24 120.89,112.32 UC1.C20
  BOTTOM w0.104: 120.94,117.61 120.94,119.18 120.79,119.33 120.79,120.11 120.76,120.14 120.76,120.78 120.79,120.81 120.79,121.48 120.36,121.91 v2(119.71,121.91)
PCIE_PTX_DRX_P7: length 124.4
  TOP w0.104: CT4.1 31.38,109.32 31.38,109.57 v2(31.2,109.76)
  IN1 w0.119: v2(31.2,109.76) 31.39,109.96 31.39,110.38 31.27,110.5 29.53,110.5 28.91,111.12 28.91,122.04 31.75,124.88 36.01,124.88 36.85,125.72 46.04,125.72 47.95,127.63 79.82,127.63 83.12,130.93 104.24,130.93 106.05,129.11 112.94,129.11 115.1,126.95 116.59,126.95 117.58,125.96 117.58,122.87 118.84,121.61 119.01,121.61 119.14,121.74 v2(119.14,121.77)
  BOTTOM w0.076: 119.66,117.61 119.66,117.59 119.67,117.58 119.67,116.93 120.41,116.19 120.41,113.39 120.34,113.31 UC1.A21
  BOTTOM w0.104: 119.66,117.61 119.66,117.73 119.63,117.76 119.63,118.41 119.66,118.44 119.66,118.66 120.13,119.13 120.13,120.48 119.67,120.94 119.37,120.94 119.13,121.18 119.13,121.77 v2(119.14,121.77)
PCIE_PTX_DRX_P8: length 120.1
  TOP w0.104: v2(33.48,109.76) 33.67,109.57 33.67,109.32 CT2.1
  IN1 w0.119: v2(118.85,120.34) 118.73,120.23 118.26,120.23 116.92,121.57 116.92,124.28 116.32,124.88 112.84,124.88 109.54,128.18 106.07,128.18 103.96,130.29 83.38,130.29 80.04,126.94 48.47,126.94 46.51,124.98 37.06,124.98 30.18,118.11 30.18,113.06 v2(33.48,109.76)
  BOTTOM w0.076: 119.15,117.61 119.15,117.59 119.14,117.58 119.14,117.06 120.24,115.96 120.24,113.69 120.07,113.52 120.07,113.21 120.09,113.15 120.1,113.14 120.1,112.86 120.06,112.75 120.06,112.58 120.13,112.38 120.18,112.33 120.37,112.33 120.51,112.19 120.51,112.08 120.44,112.01 120.33,112.01 UC1.C21
  BOTTOM w0.104: 119.15,117.61 119.15,118.77 119.67,119.29 119.67,119.96 119.41,120.22 118.97,120.22 v2(118.85,120.34)
PCIE_PTX_DRX_P9: length 213.6
  TOP w0.104: v2(238.81,125.4) 238.87,125.46 238.87,125.96 239.15,126.24 240.09,126.24 CL5.1
  IN1 w0.119: v2(118.06,116.57) 118.23,116.4 118.23,116.4 118.43,116.21 118.76,116.21 119.07,116.52 121.18,116.52 121.84,117.18 121.84,118.38 122.27,118.81 131.96,118.81 132.39,118.38 137.55,118.38 139.22,120.05 146.52,120.05 147.39,119.18 153.35,119.18 155.17,117.36 156.53,117.36 160.13,113.75 160.13,111.33 166.95,104.51 166.95,99.75 166.95,99.75 arc(169.39,87.49) 176.34,77.1 177.06,76.37 arc(185.81,70.53) 196.12,68.47 226.8,68.47 228.35,70.02 228.35,72.53 226.86,74.02 226.86,77.33 227.91,78.38 227.91,79.49 231.47,83.05 231.47,92.8 233.57,94.9 233.57,101.82 233.93,102.18 233.93,113.69 234.07,113.84 234.07,121.91 235.6,123.44 238.61,123.44 239.2,124.04 239.2,125.01 v2(238.81,125.4)
  BOTTOM w0.076: UC1.A23 118.82,113.31 118.72,113.42 118.72,115.7 118.44,115.98 118.44,116.11 118.06,116.49 v2(118.06,116.57)
PCIE_PTX_DRX_P11: length 165.9
  IN3 w0.135: v2(118.06,115.06) 116.35,115.06 116.01,115.39 116.01,117.03 114.65,118.39 111.48,118.39 108.24,121.63 105.18,121.63 103.12,123.69 86.74,123.69 83.08,120.03 79.9,120.03 79.44,120.49 71.24,120.49 70.43,121.3 67.14,121.3 66.66,121.78 50.88,121.78 49.61,120.51 48.68,120.51 43.14,114.97 43.14,108.42 42.53,107.81 42.53,98.6 41.92,97.99 41.92,92.69 39.33,90.1 38.24,90.1 37.63,89.5 37.63,88.73 36.52,87.61 36.15,87.61 35.47,86.93 35.47,86.02 34.92,85.47 34.92,73.91 27.1,66.09 27.1,60.39 20.66,53.94 20.66,51.63 19.86,50.84 v2(19.86,49.96)
  BOTTOM w0.076: UC1.C24 118.42,112.29 118.34,112.22 118.21,112.22 118.13,112.29 118.13,112.47 118.27,112.61 118.27,112.7 118.13,112.85 118.13,113.56 117.5,114.18 117.5,114.44 117.5,114.58 117.74,114.82 117.93,114.82 118.06,114.95 v2(118.06,115.06)
  BOTTOM w0.104: CN70.2 20.37,48.64 20.37,48.95 20.05,49.27 20.05,49.77 v2(19.86,49.96)
PCIE_PTX_DRX_P12: length 172.8
  IN3 w0.135: v2(17.29,50.19) 18.25,50.19 19.98,51.91 19.98,54.28 26.38,60.68 26.38,66.76 26.81,67.19 26.81,74.89 27.81,75.89 29.42,75.89 32.14,78.61 33.23,78.61 33.76,79.13 33.76,85.71 34.71,86.67 34.71,88.03 37.48,90.81 39.02,90.81 41.17,92.95 41.17,98.26 41.48,98.56 41.48,99.85 41.06,100.27 41.06,101.51 41.85,102.3 41.85,108.34 41.26,108.93 41.26,111.91 42.43,113.08 42.43,115.23 47.59,120.38 47.59,121.04 49.73,123.18 59.75,123.18 60.23,122.69 69.09,122.69 69.7,122.08 70.66,122.08 71.56,121.19 81.86,121.19 85.05,124.38 91.36,124.38 92.12,125.13 93.96,125.13 94.72,124.37 103.47,124.37 105.54,122.31 108.56,122.31 111.75,119.11 115.7,119.11 117.64,117.17 117.64,116.07 117.27,115.71 116.47,115.71 v2(116.46,115.7)
  BOTTOM w0.076: UC1.B25 117.85,112.72 117.4,113.17 117.4,113.68 117.02,114.07 117.02,115.56 116.74,115.83 116.59,115.83 v2(116.46,115.7)
  BOTTOM w0.104: v2(17.29,50.19) 16.99,49.89 16.69,49.89 16.47,49.67 CN72.2
PCIE_RCOMPN: length 2.7
  TOP w0.127: RC45.1 130,109.27 129.84,109.12 v1(129.84,108.55)
  TOP w0.381: v2(129.3,110.18) 129.63,110.18 130,109.82 RC45.1
  BOTTOM w0.254: v2(129.3,110.18) UC1.F5
PCIE_RCOMPP: length 2.7
  TOP w0.381: v2(129.3,110.81) 129.89,110.81 130.91,109.79 RC45.2
  BOTTOM w0.254: v2(129.3,110.81) UC1.E5
PCIE_WAKE#: length 476.3
  TOP w0.076: 32.92,95.41 32.92,95.57 32.74,95.74 32.74,96.16 32.58,96.32 UT1.W1
  TOP w0.112: v2(248.77,69.88) 248.77,69.46 248.56,69.25 241.15,69.25 239.35,67.46 239.35,67.06 240.23,66.18 240.23,64.58 239.75,64.1 239.34,64.1 v2(238.94,63.69) ; RE275.2 RE274.1 259.93,76.86 v2(259.74,76.67) ; v2(33.81,93.48) 32.92,94.37 32.92,95.41
  IN1 w0.076: 15.7,42.18 JNGFF3.54
  IN1 w0.119: v2(24.89,80.59) 24.92,80.57 24.92,79.31 24.41,78.8 24.41,77.35 19.58,72.52 19.58,62.91 23.7,58.79 23.7,54.99 19.87,51.17 16.76,51.17 16.28,51.65 13.88,51.65 11.39,49.16 11.39,45.03 13.99,42.43 15.45,42.43 15.7,42.18
  IN2 w0.124: v2(259.74,76.67) 258.56,76.67 257.65,77.58 251.96,77.58 250.8,76.41 249.63,76.41 249.25,76.03 247.22,76.03 246.77,76.48 246.77,77.6 246.52,77.85 244.79,77.85 244.33,78.31 236.7,78.31 235.35,76.96 235.35,76.49 234.46,75.6 v2(234.46,74.91) 233.8,74.91 232.25,73.37 229.11,73.37 228.34,72.59 228.34,71.73 226.77,70.16 225.9,70.16 225.59,69.86 221.88,69.86 220.95,68.92 207.97,68.92 206.7,70.19 187.25,70.19 185.57,71.87 182.11,71.87 172.73,81.26 172.73,83.76 170.35,86.14 170.35,88.72 168.27,90.8 168.27,105.94 163.35,110.86 163.35,120.25 159.6,124 159.6,130.19 158.52,131.27 157.19,131.27 156.37,132.08 154.32,132.08 153.35,131.11 148.77,131.11 144.93,134.95 127.06,134.95 125.91,133.79 123.72,133.79 123.11,133.18 117.78,133.18 117.19,132.6 109.69,132.6 109.31,132.98 106.2,132.98 106.04,133.13 89.05,133.13 88.67,132.75 83.88,132.75 79.39,128.26 75.66,128.26 75.34,128.59 67.41,128.59 67.11,128.28 62.52,128.28 61.54,127.31 47.46,127.31 46.05,125.89 40.79,125.89 40.44,125.54 38.12,125.54 30.76,118.17 30.76,112.58 32.9,110.44 34.94,110.44 36.8,108.57 36.8,107.63 36.68,107.5 36.68,101.92 37.16,101.43 37.16,95.31 36.01,94.16 34.44,94.16 33.81,93.53 v2(33.81,93.48)
  IN3 w0.135: v2(33.81,93.48) 33.81,92.78 34.67,91.92 34.67,91.12 34.16,90.61 33.5,90.61 32.21,89.32 31.49,89.32 30.76,88.58 29.64,88.58 28.76,87.7 28.76,85.65 26.8,83.69 26.8,83.55 24.89,81.65 v2(24.89,80.59) ; v2(248.77,69.88) 248.88,69.99 248.89,69.99 249.86,70.95 249.86,73.04 253.49,76.67 v2(259.74,76.67)
  BOTTOM w0.112: JNGFF1.55 234.14,67.15 234.55,67.55 234.55,70.22 234.97,70.64 234.97,74.4 v2(234.46,74.91) 234.46,79.29 235.77,80.61 235.77,82.35 235.6,82.53 233.7,82.53 232.98,83.25 232.98,88.55 232.49,89.04 v1(232.49,89.9) 232.49,90.67 233.12,91.3 233.12,94.42 235.46,96.76 235.46,97.29 236.66,98.5 JNGFF2.46 ; JNGFF1.70 240.2,63.4 239.85,63.05 239.5,63.05 238.94,63.61 v2(238.94,63.69)
