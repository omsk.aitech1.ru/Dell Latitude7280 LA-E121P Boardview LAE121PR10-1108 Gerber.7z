# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSA_SEN-: length 126.1
  TOP w0.112: v2(116.97,113.55) 116.97,114.01 117.17,114.21 117.17,116.13 117.43,116.39 117.43,120.13 RC166.1
  TOP w0.203: v2(52.53,101.08) 52.68,100.93 52.68,99.88 52.17,99.38 PC650.2 51.29,99.38 PC649.1 51.17,99.39 49.93,98.16 PU602.26
  IN3 w0.135: v2(116.97,113.55) 116.71,113.29 116.71,113.04 116.89,112.86 117.45,112.86 118.01,112.3 118.01,111.31 117.71,111 117.71,109.34 118.27,108.78 119.96,108.78 v2(120.1,108.92) ; v2(69.96,118.54) 69.77,118.35 69.77,118.14 69.46,117.83 68.88,117.83 68.04,118.67 66.07,118.67 65.59,119.14 53.04,119.14 51.89,118 49.72,118 47.02,115.29 47.02,109.36 48.03,108.34 49.81,108.34 50.89,107.26 50.89,103.2 52.34,101.75 52.34,101.26 v2(52.53,101.08)
  BOTTOM w0.112: v2(116.97,113.55) 116.71,113.8 115.87,113.8 115.27,114.4 114.48,114.4 108.36,120.52 106.83,120.52 103.67,123.68 95.19,123.68 94.97,123.46 89.04,123.46 87.85,122.28 86.86,122.28 86.52,122.61 86.52,124.11 83.56,127.08 76.47,127.08 75.46,126.07 75.46,125.33 75.91,124.88 75.91,123.93 72.48,120.51 70.58,120.51 69.77,119.7 69.77,118.73 v2(69.96,118.54)
  BOTTOM w0.254: UC1.H21 120.38,108.64 v2(120.1,108.92)
VSET_5105: length 6.9
  TOP w0.112: UE1.C9 v2(247.88,90.66) ; RE77.1 CE38.1 244.86,93.2 v2(245.29,93.2)
  IN2 w0.124: v2(245.29,93.2) 245.83,92.66 247.28,92.66 247.48,92.45 247.48,91.06 v2(247.88,90.66)
WIGIG_32KHZ: length 2.7
  TOP w0.112: RZ56.1 239,67.89 v2(239.03,67.86)
  BOTTOM w0.112: v2(239.03,67.86) 239.56,68.4 JNGFF1.50
WLAN_COEX1: length 23.2
  TOP w0.112: v2(242.81,75.5) 243.13,75.82 v1(243.13,76)
  BOTTOM w0.112: RZ130.2 234.83,83.41 234.98,83.26 236.97,83.26 237.49,82.75 237.49,82.41 237.67,82.23 237.67,81.15 238.83,79.98 238.83,78.87 239.57,78.13 241.41,78.13 242.93,76.61 242.93,75.62 v2(242.81,75.5) 243.05,75.26 243.05,73.99 243.57,73.46 243.57,72.91 243.32,72.66 243.32,71.58 242.52,70.78 242.52,69.72 241.7,68.9 JNGFF1.48
WLAN_COEX2: length 24.2
  TOP w0.112: v2(242.29,75.81) 241.32,75.81 v1(240.83,76.3)
  BOTTOM w0.112: JNGFF1.46 241.76,69.4 242.3,69.94 242.3,70.86 243.11,71.67 243.11,72.75 243.36,73 243.36,73.37 242.12,74.61 242.12,75.64 v2(242.29,75.81) 242.12,75.98 242.12,77.11 241.32,77.92 239.48,77.92 238.62,78.78 238.62,79.9 237.4,81.12 237.4,82.14 237.26,82.28 237.26,82.67 236.88,83.05 234.49,83.05 234.17,83.36 RZ129.2
WLAN_COEX3: length 23
  TOP w0.112: v2(236.98,81.93) v1(235.84,81.93)
  BOTTOM w0.112: JNGFF1.44 241.67,69.9 241.91,70.14 241.91,71.85 242.57,72.52 242.57,73.73 241.91,74.39 241.91,77.01 241.24,77.68 239.41,77.68 238.41,78.69 238.41,79.81 237.12,81.09 237.12,81.79 v2(236.98,81.93) 236.98,82.65 236.8,82.84 233.79,82.84 233.51,83.11 RZ128.2
WLAN_WIGIG60GHZ_DIS#: length 50
  TOP w0.112: v2(244.85,66.79) 244.68,66.79 244.07,66.18 DZ1.1 244.06,65.8 v1(243.34,65.09) ; UE1.L13 254.68,93.99 255.5,94.8 255.5,96.2 v2(255.93,96.63) 256.49,96.07 RE8.1
  IN2 w0.124: v2(255.93,96.63) 255.72,96.42 251.87,96.42 250.5,95.06 247.56,95.06 247.18,95.44 246.26,95.44 244.79,93.97 v2(244.79,92.76)
  BOTTOM w0.112: v2(244.85,66.79) 244.85,68.01 244.75,68.11 244.75,69.08 245.73,70.06 245.73,70.78 246.89,71.93 246.89,75 245.65,76.24 245.65,77.35 246.26,77.96 246.26,78.67 245.7,79.23 245.7,80.23 243.81,82.12 243.81,83.3 244.63,84.12 244.63,90.73 244.58,90.79 244.58,92.55 v2(244.79,92.76)
WLAN_WIGIG60GHZ_DIS#_R: length 2.9
  TOP w0.112: v1(241.17,66.68) v2(242.04,66.68) 242.15,66.68 DZ1.2
  BOTTOM w0.112: JNGFF1.56 241.82,66.9 v2(242.04,66.68)
WRST#: length 5.8
  TOP w0.112: v1(269.7,86.88) 270.19,87.37 270.19,87.62 RE6.2 CE500.1 270.15,89.71 269.02,89.71 268.75,89.99 UE2.4
WWAN_COEX1: length 17.1
  TOP w0.112: v2(235.19,94.71) v3(233.01,94.71)
  BOTTOM w0.112: JNGFF2.56 236.88,96 235.6,94.71 v2(235.19,94.71) 235.13,94.71 233.76,93.35 233.76,91.04 233.25,90.53 233.25,89.18 233.62,88.82 233.62,85.68 234.19,85.11 234.31,85.11 RZ130.1
WWAN_COEX2: length 16.1
  TOP w0.112: v3(234.68,95.57) 234.97,95.28 v2(235.39,95.28)
  BOTTOM w0.112: JNGFF2.54 237,96.5 235.78,95.28 v2(235.39,95.28) 235.13,95.28 233.55,93.7 233.55,91.13 233.04,90.62 233.04,89.1 233.4,88.73 233.4,85.36 RZ129.1
WWAN_COEX3: length 17.1
  TOP w0.112: v3(235,97.37) 235.62,96.75 v2(235.62,96.18)
  BOTTOM w0.112: JNGFF2.52 236.44,97 v2(235.62,96.18) 233.33,93.89 233.33,91.22 232.82,90.7 232.82,89.01 233.19,88.64 233.19,84.92 RZ128.1
WWAN_PWR_EN: length 4.5
  TOP w0.112: v1(240.36,112.76) CZ198.1 RZ43.1 239.5,111.06 v2(239.55,111.01)
  BOTTOM w0.102: v2(239.55,111.01) 239.04,110.5 JNGFF2.6
WWAN_RADIO_DIS#: length 52.3
  TOP w0.112: DZ5.1 241.26,109.99 v2(241.26,110.31) ; RE10.1 258.29,81.51 257.91,81.51 v1(257.68,81.74) 257.68,82.15 v2(257.35,82.48) 257.03,82.8 256.58,82.8 255.88,83.49 255.88,84.26 UE1.M2
  IN1 w0.119: v2(262.36,101.36) 262.36,100.65 261.77,100.07 261.77,98.83 261.45,98.51 261.45,96.09 261.87,95.67 261.87,92.75 261.57,92.44 261.57,89.22 258.71,86.36 258.71,83.84 v2(257.35,82.48)
  IN2 w0.124: v2(262.36,101.36) 262.36,101.48 258.85,104.99 256.23,104.99 255.66,105.56 246.67,105.56 241.92,110.31 v2(241.26,110.31)
WWAN_RADIO_DIS#_R: length 3.2
  TOP w0.112: DZ5.2 239.55,110.05 v2(239.55,110.31) 239.99,110.75 v1(240.21,110.75)
  BOTTOM w0.102: JNGFF2.8 239.24,110 v2(239.55,110.31)
WWAN_WAKE#: length 45.7
  TOP w0.107: v2(256.97,95.41) 256.46,94.91 v1(256.46,94.83) 256.39,94.75 256.39,94.5 255.48,93.6 UE1.M13
  TOP w0.112: RE38.1 256.97,95.53 v2(256.97,95.41)
  IN2 w0.124: v2(236.04,107.86) 236.98,107.86 237.91,106.93 242.4,106.93 244.54,104.8 255.46,104.8 255.94,104.31 258.37,104.31 260.53,102.15 260.53,100.72 v2(260.81,100.44)
  IN3 w0.135: v2(256.97,95.41) 256.97,97.67 258.65,99.35 259.71,99.35 v2(260.81,100.44)
  BOTTOM w0.112: JNGFF2.15 231.09,106.25 232.7,107.86 v2(236.04,107.86)
XCLK_BIASREF: length 16.6
  TOP w0.102: RC52.1 118.69,105.94 v2(118.69,106.26) ; v2(109.12,110.87) 109.09,110.87 RC324.1
  TOP w0.112: v1(108.94,111.34) 109.12,111.16 v2(109.12,110.87)
  IN1 w0.097: v2(109.12,110.87) 109.65,111.4 113.02,111.4 113.33,111.09 113.33,110.61 114.16,109.77 114.16,109.39 114.48,109.07 114.56,109.07 115.08,108.55 115.08,107.83 116.22,106.69 118.26,106.69 v2(118.69,106.26)
  BOTTOM w0.076: UC1.E42 108.85,110.59 v2(109.12,110.87)
XDP_DBRESET#: length 90.9
  TOP w0.112: v2(125.02,134.5) 125.4,134.88 133.63,134.88 135.24,133.27 135.24,128.93 136.2,127.96 138.76,127.96 139.76,126.96 142,126.96 142.52,126.44 145.21,126.44 146.59,125.07 150.2,125.07 153.38,121.89 153.38,114.27 v2(152.88,113.78) ; RC137.1 88.68,132.67 88.96,132.67 v2(89.41,132.22) 89.37,132.17 CC32.1
  BOTTOM w0.112: UC12.1 152.76,115.98 152.96,115.77 152.96,113.85 v2(152.88,113.78) 152.78,113.68 RC290.1 ; v2(89.41,132.22) JXDP1.48 89.41,134.33 v1(89.88,134.8) 90.27,135.19 124.33,135.19 v2(125.02,134.5)
XDP_JTAGX: length 8.2
  BOTTOM w0.076: 98.25,116.96 v1(98.25,116.52) 98.25,115.99 99,115.24 99,113.47 UC1.A59
  BOTTOM w0.102: 98.25,116.96 97.94,117.27 97.94,118.45 RC328.2
  BOTTOM w0.112: RC87.1 CC305.1 97.18,119.44 97.51,119.11 RC328.2
XDP_OBS0: length 1.9
  BOTTOM w0.112: JXDP1.21 97.51,128.31 RC239.2
XDP_OBS0_R: length 23.6
  IN1 w0.119: v2(97.24,126.23) 97.24,126.06 99.66,123.65 99.82,123.65 100.18,124 100.35,124 100.52,123.83 100.52,123.66 100.16,123.31 100.16,123.14 100.51,122.79 v2(100.51,122.63)
  BOTTOM w0.076: UC1.C55 101.07,112.76 100.94,112.89 100.94,114.72 100.82,114.83 100.82,116.1 100.89,116.16 100.89,116.76 100.67,116.98 100.67,120.09
  BOTTOM w0.112: v2(100.51,122.63) 100.67,122.47 100.67,120.09 ; RC239.1 97.68,126.69 100.15,126.69 100.32,126.52 100.32,126.38 99.89,125.95 97.52,125.95 v2(97.24,126.23)
XDP_OBS1: length 2
  BOTTOM w0.112: JXDP1.23 96.91,128.6 RC240.2
XDP_OBS1_R: length 23.8
  IN1 w0.119: v2(101.12,122.63) 101.12,122.44 100.81,122.14 100.25,122.14 100.04,122.35 100.04,122.63 96.43,126.23 v2(96.35,126.23)
  BOTTOM w0.076: UC1.D55 101.07,111.92 101.39,112.23 101.39,112.46 101.34,112.51 101.34,113.38 101.1,113.61 101.1,114.79 100.99,114.9 100.99,116.03 101.05,116.09 101.05,116.89 100.93,117.02 100.93,119.42 101.09,119.58 101.09,120.09
  BOTTOM w0.112: RC240.1 94.13,127.13 93.98,126.97 93.98,126.43 94.17,126.23 v2(96.35,126.23) ; v2(101.12,122.63) 101.09,122.6 v1(101.09,121.83) 101.09,120.09
XDP_OBS2_R: length 3.1
  BOTTOM w0.076: UC1.B54 101.92,112.95 101.92,114.78 101.65,115.05 T10.1
XDP_OBS3_R: length 4.4
  BOTTOM w0.076: UC1.C56 100.51,112.24 100.77,112.51 100.77,114.65 100.61,114.81 T11.1
XDP_PRSNT_PIN1: length 7.3
  IN1 w0.119: v2(103.35,128.79) 103.35,128.31 102.16,127.13 v2(100.69,127.13)
  BOTTOM w0.112: v2(103.35,128.79) 103.51,128.95 JXDP1.1 ; RC122.1 RC121.1 v2(100.69,127.13)
XDP_TMS: length 16.7
  TOP w0.112: v2(79.58,125.47) 80.88,126.77 84.29,126.77 85.6,128.08 85.6,131.02 85.79,131.21 v2(85.79,132.24)
  BOTTOM w0.112: RC228.1 78.46,123.39 80.22,123.39 80.3,123.47 UC8.9 80.3,124.74 v1(79.99,125.06) v2(79.58,125.47) ; JXDP1.58 86.41,132.86 v2(85.79,132.24)
XTAL24_IN: length 13.8
  TOP w0.104: v2(112.86,110.29) 112.86,110.35 113.08,110.56 113.16,110.56 113.62,111.02 113.62,111.9 113.74,112.02 113.74,114.08 114.75,115.09 114.75,115.81 114.91,115.97 114.96,115.97 v2(115.14,116.15)
  BOTTOM w0.104: v2(112.86,110.29) 112.8,110.23 111.75,110.23 111.47,110.51 UC1.E37 ; YC1.3 114.37,119.68 114.37,119.16 CC21.1 114.34,119.1 RC46.2 114.92,117.9 114.92,117.08 114.75,116.91 114.75,116.47 114.86,116.37 114.92,116.37 v2(115.14,116.15)
XTAL24_OUT: length 10.1
  TOP w0.104: v2(112.86,110.88) 112.97,110.78 113.09,110.78 113.41,111.1 113.41,111.98 113.54,112.11 113.54,114.16 114.55,115.17 v2(114.55,116.15)
  BOTTOM w0.104: v2(114.55,116.15) 114.55,116.15 114.55,117 114.72,117.16 114.72,117.95 114.46,118.21 RC46.1 RC295.1 ; v2(112.86,110.88) 112.57,110.59 UC1.E35
XTAL24_OUT_R: length 4.9
  BOTTOM w0.102: CC22.1 113.94,119.59 113.94,120.94 YC1.1
  BOTTOM w0.112: CC22.1 113.36,119.1 112.53,118.27 RC295.2
XTAL_25_IN: length 6.8
  TOP w0.076: UT1.D22 25.52,106.38 25.45,106.44 25.45,107.18 25.18,107.44
  TOP w0.112: YT1.1 21.82,109.76 CT21.1 22.76,107.66 24.97,107.66 25.18,107.44
XTAL_25_OUT: length 4.2
  TOP w0.076: UT1.D23 25.68,106.67 25.68,107.36 25.3,107.74
  TOP w0.112: RT40.1 22.68,108.46 23.18,107.96 25.08,107.96 25.3,107.74
XTAL_25_OUT_R: length 5.4
  TOP w0.112: YT1.3 23.21,110.76 23.21,109.42 23.53,109.1 23.89,109.1 CT20.1 RT40.2
XTALI: length 6.3
  TOP w0.112: YL1.1 248.3,118.74 CL14.1 248.32,119.45 RL11.2 249.21,121.12 v1(249.08,121.25) 248.98,121.35 248.63,121.35 247.68,122.3 UL1.10
XTALO: length 3.9
  TOP w0.112: UL1.9 247.28,122.23 v1(247.73,121.77) 248.3,121.21 RL11.1 RL34.2
XTALO_R: length 5
  TOP w0.112: RL34.1 246.52,120.27 247.33,119.45 CL13.1 247.78,119.11 247.78,117.41 YL1.3
Z2805: length 3.5
  TOP w0.127: v1(260.12,118.58) 260.5,118.2 v2(261.26,118.2)
  TOP w0.508: RL18.1 v2(261.26,118.2)
  BOTTOM w0.508: TL1.22 v2(261.26,118.2)
Z2806: length 3
  TOP w0.127: v2(268.88,118.2) 268.88,117.69 v1(268.68,117.49)
  TOP w0.508: RL16.1 v2(268.88,118.2)
  BOTTOM w0.508: TL1.16 v2(268.88,118.2)
Z2807: length 3.6
  TOP w0.127: v2(262.53,118.18) 263.33,118.18 v1(263.7,118.55)
  TOP w0.508: RL17.1 v2(262.53,118.18)
  BOTTOM w0.508: TL1.21 v2(262.53,118.18)
Z2808: length 3.1
  TOP w0.127: v2(270.15,118.18) 270.15,117.75 v1(270.43,117.47)
  TOP w0.508: RL15.1 v2(270.15,118.18)
  BOTTOM w0.508: TL1.15 v2(270.15,118.18)
N04748: length 5.7
  TOP w0.203: PU901.3 59.12,56.44 59.28,56.27 v2(59.84,56.27)
  BOTTOM w0.112: PR929.1 60.84,56.87 61.2,57.22 v1(61.2,58.72)
  BOTTOM w0.254: PC939.1 59.84,56.36 v2(59.84,56.27) 60.04,56.48 60.54,56.48 PR929.1
N16399089: length 6.4
  BOTTOM w0.508: PR916.2 50.52,59.45 50.33,59.26 v1(50.24,59.26) PD903.1 ; PD903.1 PD904.1 ; PD903.1 48.63,58.97 48.63,57.83 PD901.1
N16400770: length 42.5
  TOP w0.254: PR901.3 50.39,83.28 50.14,83.03 50.14,81.81 49.71,81.38 46.24,81.38 45.95,81.67 44.65,81.67 v2(44.55,81.57)
  IN3 w0.203: v2(49.95,60.72) 44.93,60.72 39.88,65.76 39.88,75.53 41.75,77.4 41.75,79.22 44.1,81.57 v2(44.55,81.57)
  BOTTOM w0.254: PR910.1 53.01,62.33 51.56,62.33 v2(49.95,60.72)
N16404606: length 3
  BOTTOM w0.112: v1(44.89,60.46) 44.89,60.01 45.11,59.79 PR950.1
  BOTTOM w0.254: PD905.3 43.17,59.52 PR939.2 PR950.1
N16404788: length 5.9
  TOP w0.112: v2(43.52,57.92) v1(42.98,57.92)
  IN1 w0.254: v2(43.52,57.92) 44.47,57.92 v2(46.25,56.14)
  BOTTOM w0.254: v2(43.52,57.92) 42.82,57.92 PD905.1 ; v2(46.25,56.14) 46.25,56.14 PU903.1
N16775301: length 4
  TOP w0.112: v2(65.49,70.88) 65.87,71.26 v1(65.87,71.41)
  TOP w0.254: PR206.1 PR204.2 PC208.2 65.43,70.81 v2(65.49,70.88)
  BOTTOM w0.254: PU200.16 65.84,70.66 65.62,70.88 v2(65.49,70.88)
N16775385: length 8.7
  TOP w0.112: v2(70.69,71.96) 70.38,71.96 69.11,70.69 69.11,66.88 v1(69.24,66.75)
  TOP w0.254: PC218.1 v2(70.69,71.96)
  BOTTOM w0.254: v2(70.69,71.96) 69.99,71.26 69.79,71.26 69.64,71.11 PU200.3
N16775433: length 3.5
  TOP w0.102: PR202.2 66.51,69.04 65.94,68.46 v1(65.94,66.94)
N16775513: length 1.4
  BOTTOM w0.112: PR203.2 63.02,69.25 v1(62.66,69.61)
N16775517: length 2.5
  TOP w0.112: v1(64.98,66.05) 64.98,67.7 65.37,68.08 v2(65.37,68.4)
N16776853: length 4.6
  TOP w0.102: PC207.1 64.35,68.58 64.35,67.64 v3(63.65,66.94)
  TOP w0.254: v2(65.17,69.79) 65.18,69.79 65.18,69.8 64.93,69.56 PC207.1
  BOTTOM w0.254: PU200.14 65.2,69.76 v2(65.17,69.79)
N16783014:
  vias: v1(156.87,77.4) v2(155.95,77.48) v2(155.95,76.9)
N16783095: length 0.9
  BOTTOM w0.254: PC113.2 155.07,79.72 PR108.1
N16783134: length 3.2
  BOTTOM w0.112: PR117.1 186.1,60.59 187.35,60.59 v1(187.51,60.43)
  BOTTOM w0.254: PC127.2 185.36,59.84 PR117.1
N16783223: length 2.7
  TOP w0.112: v2(186.84,57.1) 186.84,57.67 v3(187.83,58.66)
  TOP w0.508: PC119.1 186.71,57.22 v2(186.84,57.1)
N16784595: length 1.1
  BOTTOM w0.112: PR100.2 v1(156.36,70.06)
N16784799: length 1.6
  BOTTOM w0.112: v1(189.17,50.05) 188.99,50.23 PC114.1
N17185092: length 3.8
  BOTTOM w0.112: PR1214.2 41.35,103.01 40.91,102.57 v1(40.13,102.57)
  BOTTOM w0.254: PR1214.2 PR1218.2 40.59,104.72 PQ1204.6
N17188126: length 2.2
  TOP w0.112: v2(38.29,62.6) v1(38.86,62.6)
  TOP w0.254: PR1211.2 38.25,62.56 v2(38.29,62.6)
  BOTTOM w0.254: PU1200.1 v2(38.29,62.6)
N17188417: length 2.4
  BOTTOM w0.254: PR1215.2 36.79,63.65 36.79,62.18 37.02,61.95 PU1200.2
N17263481: length 4.6
  TOP w0.112: PU602.39 46.91,92.77 46.4,92.26 45.73,92.26 45.45,92.53 PR612.2 45.25,92.17 45.44,91.98 45.44,91.54 PR614.2
N17264741: length 2.6
  TOP w0.203: PR616.2 45.74,91.13 46.98,92.37 PU602.40
N17335638: length 4.5
  TOP w0.112: v1(144.93,59.07) PR516.1 146.07,59.08 PC515.2 PR515.2 147.38,59.94 148.01,59.31 PU503.3
N17340170: length 3.9
  BOTTOM w0.254: PQ1205.1 v1(38.78,63.7) 37.76,63.7 PR1215.1 PR1226.2
N17370862: length 4.6
  TOP w0.508: v2(46.02,110.87) 48.51,113.36 PQ5.1
  BOTTOM w0.508: PC4.2 46.02,110.88 v2(46.02,110.87)
N17370885: length 5.2
  TOP w0.112: PR10.2 52.41,114.04 52.96,114.59 52.96,115.62 v1(52.6,115.97)
  TOP w0.508: PR10.2 PR15.1 51.93,113.12 51.59,112.77 PQ5.2
N17370921: length 2.4
  TOP w0.112: PQ1.6 v1(53.49,111.11)
  TOP w0.457: PR15.2 52.77,112.2 52.89,112.33 PQ1.6
N17370927: length 2.5
  BOTTOM w0.112: PQ7.1 44.03,112.44 v1(44.42,112.84)
  BOTTOM w0.254: PQ7.1 44.03,111.09 PR16.2
N17370961: length 10
  TOP w0.254: PR3.1 41.44,119.73 38.95,119.73 37.24,121.45 PQ2.1 37.24,122.76 PL3.1 37.17,124.26 PR6.2
N17370983: length 8.9
  TOP w0.254: PQ2.3 37.06,121.04 38.77,119.33 41.95,119.33 PR3.2 PR5.1
N17370995: length 2.4
  TOP w0.254: PR6.1 PR8.2 36.09,126.49 PQ3.2
N17370999: length 3.8
  TOP w0.254: PQ2.2 35.15,124.88 PQ3.1 34.74,125.3 PR7.2
N17371029: length 1
  BOTTOM w0.112: PR18.1 48.4,122.38 v1(48.54,122.52)
N17371043: length 2.4
  BOTTOM w0.112: PR18.2 49.31,121.92 v1(49.86,122.46)
  BOTTOM w0.254: PR18.2 49.68,121.18 PQ6.1
N17371182: length 2.3
  BOTTOM w0.112: PQ6.2 v1(51.58,122.24)
  BOTTOM w0.254: PR23.2 51.65,121.05 PQ6.2
N17371184: length 2.2
  BOTTOM w0.112: PR23.1 52.73,119.54 v1(53.03,119.24)
  BOTTOM w0.254: PR23.1 53.07,120.14 53.33,119.88 PU1.4
N17371196: length 1.2
  BOTTOM w0.254: PR21.2 56.54,121.18 PU1.1
N17371207: length 3.5
  BOTTOM w0.112: v1(58.7,120.81) 58.42,120.53 PR22.1
  BOTTOM w0.254: PR22.1 PR27.1 58.38,119.64 58.57,119.84 PQ8.1
N17372066: length 3.5
  TOP w0.112: v1(57.9,115.45) 57.21,114.77 PR19.2
  TOP w0.254: PR19.2 56.97,114.76 PR17.2 56.11,114.34 PQ1.3
N17372074: length 4.3
  TOP w0.112: PR25.1 54.33,115.66 v1(54.27,115.72)
  TOP w0.254: PQ1.5 53.17,112.98 52.92,113.23 52.92,113.93 53.17,114.18 54.08,114.18 54.33,114.44 PR25.1
N17372833: length 6.2
  TOP w0.112: PR1201.2 40.03,52.41 v1(39.8,52.41)
  TOP w0.203: PC1206.1 40.58,54.74 v2(40.28,54.74) ; PC1206.1 PR1219.1 PR1201.2 ; PC1206.1 40.98,55.14 PR1203.1
  BOTTOM w0.203: PU1201.3 v2(40.28,54.74)
N17479322: length 8.4
  TOP w0.254: PR1252.1 50.2,102.18 v2(50.54,102.18) 50.91,102.18 PR1251.2
  BOTTOM w0.254: v2(50.54,102.18) 49.58,102.18 48.92,101.52 48.65,101.52 v1(48.33,101.2) 48.03,100.9 46.84,100.9 46.46,100.52 44.6,100.52 PQ1215.2
N17494434: length 11.6
  TOP w0.112: PR1239.2 v1(35.58,53.35)
  TOP w0.203: PR1239.2 PR1246.1 PC1211.1 36.47,55.13 35.97,54.62 v2(35.84,54.62) 35.44,54.62 PR1238.1
  BOTTOM w0.254: PU1201.5 36.37,54.09 v2(35.84,54.62) 35.51,54.62 PD1205.1 34.69,54.25 34.15,54.79 34.15,56.51 PR1255.2 33.7,56.96 PQ1212.1
N17509431: length 4.4
  TOP w0.254: PR949.2 v2(56.6,51.45) 56.6,50.76 PR935.1
  BOTTOM w0.254: PC947.1 56.98,53.5 v1(56.59,53.11) PR947.1 56.59,51.46 v2(56.6,51.45)
N17509921: length 2.4
  BOTTOM w0.112: v1(42.59,60.44) 42.59,60.24 PD905.2
  BOTTOM w0.254: PD905.2 41,59.51 PR941.2
N17522701: length 2.2
  BOTTOM w0.112: v1(48.26,55.1) PR942.2
  BOTTOM w0.254: PU903.2 46.81,54.75 47.17,55.1 PR942.2
N17670003: length 4.2
  TOP w0.203: PU901.30 57.12,54.46 57.62,53.96 v2(57.62,53.67) 57.62,53.11 PR936.1
  BOTTOM w0.112: v1(58.46,52.09) 58.46,52.18 PR948.1
  BOTTOM w0.254: PR948.1 57.62,53.05 v2(57.62,53.67)
N17739728: length 4.2
  BOTTOM w0.112: PR1224.1 39.27,60.13 v1(38,60.13)
  BOTTOM w0.254: PQ1205.3 40.08,61.31 39.79,61.02 PR1224.1 PR1221.2
N17747591: length 3.5
  TOP w0.254: PR28.1 61.06,119.75 PR26.2 61.06,118.2 v2(61.05,118.18)
  BOTTOM w0.102: PQ8.3 v3(61.99,119.19)
  BOTTOM w0.254: v2(61.05,118.18) PQ8.3
N17747606: length 2.1
  BOTTOM w0.112: v1(61.06,122.57) PR29.2
  BOTTOM w0.254: PR29.2 61.05,121.6 PQ8.2
N17765266: length 3.8
  TOP w0.203: PR933.2 v2(54.82,53.68) 54.82,53.8 55.52,54.49 PU901.26
  BOTTOM w0.112: PR951.2 53.82,53.08 54.42,53.68 v2(54.82,53.68)
N17768164: length 3.6
  BOTTOM w0.112: PQ1210.5 51.4,51.13 51.78,51.51 51.78,52.21 51.98,52.41 PR1245.2 51.98,53.67 v1(52.12,53.81)
N17769037: length 5.6
  TOP w0.112: PR1230.1 46.19,50.75 46.46,50.48 v2(46.86,50.48) v1(46.86,49.95)
  BOTTOM w0.112: PQ1207.6 v2(46.86,50.48) ; v2(46.86,50.48) PQ1211.4 ; v2(46.86,50.48) 46.86,52.43 PR1258.2
N17769560: length 3.5
  TOP w0.112: v1(48.28,49.95) v2(48.28,50.49) 48.28,50.86 PR1242.2 PR1233.1
  BOTTOM w0.112: PQ1211.5 48.03,51.13 48.28,50.87 v2(48.28,50.49)
N17769738: length 4.4
  BOTTOM w0.112: PQ1211.2 49.74,51.13 49.94,51.32 49.94,52 PR1235.1 PR1257.2 48.3,53.34 v1(48.72,53.76)
N17770477: length 4.1
  TOP w0.112: PR1232.1 44.91,51 45.24,51 v2(45.53,50.71) v1(45.53,50.04)
  BOTTOM w0.112: 44.75,51.26 44.75,51.65 44.62,51.78 PQ1207.3 ; 44.75,51.26 44.63,51.13 PQ1207.2 ; 44.75,51.26 44.88,51.13 45.11,51.13 v2(45.53,50.71)
N17771093: length 3.4
  BOTTOM w0.112: PQ1207.5 45.58,51.13 45.11,51.6 45.11,52.03 44.88,52.26 44.27,52.26 43.82,52.76 PR1241.2
N17771333: length 12.1
  TOP w0.112: PR1234.1 PR1261.2 42.88,50.48 v2(42.27,50.48) 42.27,50.1 v1(42.01,49.84)
  IN2 w0.124: v2(48.74,51.78) 48.74,50.23 48.44,49.92 42.82,49.92 v2(42.27,50.48)
  BOTTOM w0.112: PQ1208.6 v2(42.27,50.48) ; PQ1211.1 v2(48.74,51.78)
N17771663: length 3.1
  BOTTOM w0.112: v1(40.61,52.84) PR1259.1 41.54,51.94 41.38,51.78 PQ1208.3 PQ1208.2
N17772624: length 4
  TOP w0.112: PR1244.2 PR1260.2 v2(42.25,51.13) 42.62,51.13 PR1261.1 42.95,52.33 v1(43.05,52.44)
  BOTTOM w0.112: PQ1208.5 v2(42.25,51.13)
N17801240: length 3.6
  TOP w0.254: PR1229.1 29.69,121.92 30.06,121.55 PQ1206.4 31.07,121 PC1210.1 PR1228.2
N17802718: length 2.8
  BOTTOM w0.112: v1(48.97,102.31) 47.84,102.31 v2(47.71,102.18)
  BOTTOM w0.254: v2(47.71,102.18) 47.24,101.71 PQ1215.1
N17804163: length 9.4
  TOP w0.254: PR1207.2 PC1203.2 ; PR1207.2 48.36,108.7 PR1213.1 48.36,106.46 47.93,106.03 v2(47.14,106.03) ; PR1207.2 48.78,108.71 49.05,108.98 49.05,109.28 49.32,109.55 PQ1202.4
  BOTTOM w0.254: PQ1203.1 44.78,105.38 45.7,105.38 46.35,106.03 v2(47.14,106.03)
N17890941: length 2.9
  BOTTOM w0.112: PU1200.4 34.71,61.3 v1(34.38,61.63)
  BOTTOM w0.254: PR1216.1 36.36,60.88 35.94,61.3 PU1200.4
N17892124: length 2.8
  TOP w0.254: PR1252.2 48.87,101.76 48.61,101.76 47.87,101.02 PQ1214.6
N18264144: length 3.5
  BOTTOM w0.112: PR20.1 42.07,109.99 41.68,109.59 40.57,109.59 v1(40.19,109.22)
  BOTTOM w0.254: PR20.1 42.07,111.17 PQ7.2
N18265642: length 63.1
  TOP w0.112: v2(34.83,60.74) v3(35.71,60.74)
  TOP w0.254: PQ1201.2 46.82,106.94 v2(47.14,106.63)
  IN2 w0.124: v2(34.83,60.74) 35.41,60.74 35.65,60.98 35.65,63.01 36.42,63.78 36.42,65.67 34.54,67.55 34.54,71.87 36.12,73.44 36.12,79.13 38.12,81.14 38.12,85.56 40.32,87.75 40.32,94.05 39.42,94.96 39.42,99.68 40.16,100.42 40.16,101.41 39.22,102.35 39.22,104.13 39.8,104.71 39.8,105.52 39.09,106.23 v2(38.56,106.23)
  BOTTOM w0.112: v2(47.14,106.63) 46.32,106.63 45.92,106.23 42.16,106.23 42.11,106.29 38.61,106.29 v2(38.56,106.23)
  BOTTOM w0.254: v2(34.83,60.74) 35.34,60.23 PR1216.2
N18265900: length 0.9
  TOP w0.254: PQ1201.5 PR1220.2
N18266224: length 8.2
  TOP w0.203: PC1213.1 PR1238.2 ; PC1213.1 v2(35.83,56.7) ; PC1213.1 PR1240.2 PR1243.1
  BOTTOM w0.112: v1(35.58,57.96) 35.14,57.52 PD1205.2
  BOTTOM w0.203: v2(35.83,56.7) 35.77,56.65 PD1205.2 35.14,56.34 35.46,56.02 35.84,56.02 36.47,55.39 PU1201.7
N18266545: length 101.8
  TOP w0.112: PQ1209.5 28.04,124.22 PC1214.1 26.86,124.2 v2(26.6,124.46)
  TOP w0.203: PR1243.2 33.36,58.84 v2(33.37,58.85)
  IN2 w0.124: v2(33.37,58.85) 34.86,58.85 35.9,59.89 35.9,62.9 36.67,63.67 36.67,65.77 34.79,67.65 34.79,71.64 36.42,73.26 36.42,79.11 38.38,81.06 38.38,85.46 40.56,87.64 40.56,98.64 40.41,98.79 40.41,101.53 39.47,102.47 39.47,103.95 40.08,104.56 40.08,106.28 37.64,108.72 37.24,108.72 35.2,110.75 32.97,110.75 31.05,112.67 31.05,118.11 37.21,124.27 v2(39.5,124.27)
  BOTTOM w0.112: v2(26.6,124.46) 26.6,126.73 26.82,126.96 v3(35.71,126.96) 35.95,126.96 38.64,124.27 v2(39.5,124.27)
N18267253: length 8.1
  TOP w0.203: PR1248.1 v2(32.41,55.95) PR1250.1 32.42,55.32 PR1249.1
  BOTTOM w0.102: v1(32.85,61.22) 33.05,61.02 PQ1212.2
  BOTTOM w0.254: PQ1212.2 32.12,59.09 32.12,56.25 v2(32.41,55.95)
N18268286: length 4.3
  BOTTOM w0.112: PQ1205.2 42.06,61.8 v1(42.66,62.39)
  BOTTOM w0.254: PR1225.2 39.06,62.62 40.55,62.62 PQ1205.2
N18277029: length 3.8
  TOP w0.254: v2(141.88,127.39) 141.26,128.01 PR425.2 141.26,128.22 140.58,128.9 PR404.2
  BOTTOM w0.112: v2(141.88,127.39) v1(141.88,126.68)
  BOTTOM w0.254: PU401.14 v2(141.88,127.39)
N18277134: length 9.8
  TOP w0.112: PR410.2 PR426.2 163.09,127.79 163.09,126.3 v1(162.69,125.89) 162.25,125.46 v2(162.25,125.44)
  BOTTOM w0.112: v2(162.25,125.44) 162.2,125.38 158.6,125.38 157.75,126.23 PU402.14
N18278112: length 3.4
  TOP w0.203: PR620.2 46.63,90.94 47.01,91.32 48.33,91.32 PU602.1
N18278782: length 1.3
  TOP w0.112: PC930.1 v1(59.51,62.62)
N18278920: length 5.5
  TOP w0.112: PU901.21 54.07,56.84 53.99,56.76 53.62,56.76 53.1,56.24 53.1,55.65 52.9,55.45 52.6,55.45 52.39,55.66 v4(52.39,56.53) 52.39,56.84 52.08,57.15 51.8,57.15 PR920.2
N18278998: length 5.5
  TOP w0.112: PR922.2 51.8,56.91 51.98,56.91 52.15,56.74 52.15,55.56 52.5,55.21 v4(52.7,55.21) 53,55.21 53.34,55.55 53.34,56.14 53.72,56.52 53.98,56.52 54.06,56.44 PU901.22
N18287403: length 3.1
  TOP w0.112: PR19.1 57.61,113.23 v1(57.87,113.23)
  TOP w0.254: PR19.1 56.53,113.85 55.65,112.98 PQ1.2
N18287500: length 1.1
  BOTTOM w0.254: PU1.2 PR22.2
N18288083: length 1.1
  BOTTOM w0.254: PU903.4 43.27,54.1 PR946.1
N18288371: length 4.2
  BOTTOM w0.112: v1(39.93,104.29) 39.93,105.1 40.42,105.59 40.75,105.59 41.24,105.11 PQ1204.5
  BOTTOM w0.254: PR1218.1 42.26,104.18 41.91,104.53 41.69,104.53 41.24,104.99 PQ1204.5
N18288510: length 2.7
  BOTTOM w0.112: v1(39.85,107.94) 40.26,108.35 40.79,108.35 41.12,108.01 PR1223.1
  BOTTOM w0.254: PQ1204.2 41.24,107.95 PR1223.1
N18290168: length 2.2
  TOP w0.203: 56.93,54.11 56.72,54.32 PU901.29
  TOP w0.254: PR949.1 56.96,53.34 v1(56.96,53.88) 56.93,53.91 56.93,54.11
N18290418: length 3.6
  BOTTOM w0.112: v1(156.03,133.13) 156.03,132.54 156.37,132.19 PR423.1
  BOTTOM w0.254: PR423.1 PR424.1 156.37,130.81 156.75,130.43 PU402.5
N18325201: length 2.4
  TOP w0.254: CL16.1 v2(261.11,130.38)
  BOTTOM w0.254: TL1.3 261.26,129.87 261.11,130.02 v2(261.11,130.38)
N18325205: length 3.7
  TOP w0.112: v1(261.95,131.43) 262.34,131.04 v2(262.34,130.38)
  TOP w0.254: v2(262.34,130.38) 262.32,130.35 CL17.1
  BOTTOM w0.254: v2(262.34,130.38) 262.53,130.19 TL1.4
N18325209: length 3
  TOP w0.112: v1(268.21,127.4) 268.83,127.4 v2(268.88,127.46)
  TOP w0.254: v2(268.88,127.46) CL20.1
  BOTTOM w0.254: TL1.9 v2(268.88,127.46)
N18325213: length 3
  TOP w0.112: v1(269.62,127.25) 269.95,127.25 v2(270.15,127.46)
  TOP w0.254: v2(270.15,127.46) CL21.1
  BOTTOM w0.254: TL1.10 v2(270.15,127.46)
N18364501: length 3.8
  BOTTOM w0.112: v1(106.25,126.33) RV97.1 107.45,126.5 108.08,126.5 108.41,126.83 109.38,126.83 109.51,126.96 UV7.20
N18366912: length 2.4
  BOTTOM w0.112: CV96.1 109.49,125.93 109.74,125.93 110.34,126.53 110.41,126.53 110.71,126.82 UV7.17
N18421193: length 3.3
  TOP w0.112: PR624.1 v1(71.4,114.37)
  TOP w0.254: v2(72.48,115.71) PR624.1
  BOTTOM w0.254: PL614.3 72.35,115.58 v2(72.48,115.71)
N18490882: length 2.4
  TOP w0.112: UI3.16 279.65,76.52 RI14.2 279.67,77.29 v1(279.83,77.46)
N18762046: length 0.9
  TOP w0.112: RA17.2 CA33.1
N18762152: length 1.4
  TOP w0.112: CZ127.1 248.59,63.43 UZ5.10
N18762172: length 1.4
  TOP w0.112: UZ5.12 248.51,64.23 CZ126.1
N18762349: length 4
  TOP w0.203: UA1.27 255.93,56.73 254.47,55.27 RA44.1 253.44,55.01 CA51.1
N18762353: length 4.1
  TOP w0.203: UA1.7 257.13,64.57 v1(257.12,64.58) 257.13,64.58 257.13,66.82 CA53.1
N18762355: length 3.3
  TOP w0.152: UA1.39 260.83,58.94 261.59,58.18 v1(261.67,58.18) 261.77,58.08 263.19,58.08 CA52.1
N18762401: length 6.3
  TOP w0.102: v1(249.83,57.29) 250.1,57.55 RA53.1
  TOP w0.203: UA1.20 253.42,59.74 252.88,59.19 250.23,59.19 RA54.1 RA53.1
N18762411: length 5.7
  TOP w0.102: CA29.1 v1(261.9,53.29)
  TOP w0.112: UA1.35 259.13,56.89 259.61,56.4 260.5,56.4 261.2,55.7 261.2,55.45 CA29.1
N18762416: length 3.2
  TOP w0.112: UA1.37 260.72,58.14 260.84,58.01 260.84,56.5 261.2,56.14 CA29.2
N18762426: length 2.7
  TOP w0.112: CA35.1 255.36,55.54 v1(255.94,56.11) 256.12,56.3 256.12,56.51 256.33,56.72 UA1.28
N18762428: length 2.8
  TOP w0.112: UA1.34 258.73,56.9 259.49,56.14 260.06,56.14 260.31,55.89 CA49.1
N18762438: length 1.9
  TOP w0.203: CA25.1 253,59.89 253.24,60.14 UA1.19
N20151644: length 42.8
  TOP w0.254: PR901.2 49.47,83.28 49.73,83.02 49.73,81.98 49.54,81.79 46.37,81.79 46.1,82.05 44.65,82.05 v2(44.55,82.15)
  IN3 w0.203: v2(44.55,82.15) 44.25,82.15 41.41,79.31 41.41,77.52 39.54,75.66 39.54,65.62 45.08,60.08 v2(49.95,60.08)
  BOTTOM w0.254: v2(49.95,60.08) 50.01,60.08 v3(50.93,61) 51.15,61.22 53.22,61.22 PR909.1
N20880735: length 1.8
  BOTTOM w0.112: PC307.2 v1(152.5,87.96)
  BOTTOM w0.254: PR308.1 153.43,87.09 PC307.2
N24606174: length 4
  TOP w0.112: v1(154.37,88.03) 153.76,87.43 PC313.1
  TOP w0.254: PC313.1 153.76,86.51 v2(154.73,85.53)
  BOTTOM w0.254: PU301.5 v2(154.73,85.53)
N27076067: length 2.2
  BOTTOM w0.112: PC944.1 54.71,52.1 54.71,51.3 v1(55.04,50.96)
  BOTTOM w0.254: PC944.1 PR934.2
N27077001: length 121.2
  TOP w0.254: v2(171.45,49.57) 171.55,49.67 171.55,51.78 171.3,52.03 PR917.2
  IN2 w0.254: v2(171.45,49.57) 171.12,49.57 171.02,49.46 162.98,49.46 158.03,54.42 148.59,54.42 146.84,52.67 142.55,52.67 139.07,49.95 71.75,49.95 70.36,51.34 70.36,52.4 68.44,54.32 65.53,54.32 64.64,53.43 62.99,53.43 v2(62.66,53.76)
  BOTTOM w0.254: PR937.2 62.32,55.83 63.13,55.01 v1(63.13,54.23) v2(62.66,53.76)
N28424999: length 7.5
  BOTTOM w0.076: UC1.AW71 91.67,92.33 90.82,92.33 90.38,91.9 90.38,91.6 90.03,91.25 90.03,90.88
  BOTTOM w0.112: T113.1 88.12,87.77 88.73,88.38 88.73,88.8 90.03,90.09 90.03,90.88
N28425002: length 9.8
  BOTTOM w0.076: UC1.AW70 92.25,92.13 91.25,92.13 91.22,92.17 90.91,92.17 90.6,91.86 90.6,91.48 90.3,91.17
  BOTTOM w0.102: 89.97,89.7 90.3,90.03 90.3,91.17
  BOTTOM w0.112: 89.97,89.7 88.97,88.71 88.97,88.24 88.14,87.4 86.37,87.4 T114.1
N28489601: length 8.7
  BOTTOM w0.112: v1(224.9,81.29) 226.54,81.29 RC222.1 227.4,81.53 229.17,81.53 230.11,82.47 230.11,83.7 230.11,84 230.01,84.16 SW1.2
N28769860: length 3.4
  BOTTOM w0.112: PR422.1 v1(140.44,134.53)
  BOTTOM w0.254: PR422.1 PR421.2 140.44,132.14 140.88,131.7 PU401.5
N28810563: length 1.6
  TOP w0.112: UZ2.10 249.61,111.6 249.44,111.77 CZ110.1
N28811129: length 1.3
  TOP w0.112: UZ3.10 155.34,60.74 CZ114.1
N28856399: length 9.5
  BOTTOM w0.076: 90.23,89.3 91.25,90.32 92.4,90.32 92.58,90.5 92.58,91.15 UC1.BA70
  BOTTOM w0.107: T16.1 86.38,86.88 88.43,86.88 89.47,87.92 89.47,88.54 90.23,89.3
N28856402: length 11.6
  BOTTOM w0.076: 90.51,91.02 90.89,91.4 91.4,91.4 91.48,91.48 92.05,91.48 92.22,91.65 92.73,91.65 UC1.BA68
  BOTTOM w0.102: 90.51,91.02 90.51,89.9 90.17,89.56
  BOTTOM w0.107: 90.17,89.56 89.23,88.62 89.23,88.1 88.26,87.13 85.37,87.13 T17.1
N28857231: length 11.4
  BOTTOM w0.076: 91.05,89.48 91.55,89.99 92.63,89.99 93.33,90.69 UC1.BB68
  BOTTOM w0.102: 91.05,89.48 90.37,88.81
  BOTTOM w0.107: 88.26,86.12 87.81,86.12
  BOTTOM w0.112: 87.81,86.12 85.11,86.12 T12.1 ; 90.37,88.81 89.98,88.42 89.98,87.54 88.56,86.12 88.26,86.12
N28857234: length 7.9
  BOTTOM w0.076: UC1.BB69 92.9,90.49 92.56,90.15 91.4,90.15 90.43,89.18
  BOTTOM w0.112: 90.43,89.18 89.71,88.47 89.71,87.74 88.47,86.5 T13.1
N28857237: length 1.2
  TOP w0.112: T14.1 125.52,98.54 v2(125.52,98.47)
  BOTTOM w0.102: UC1.AK13 125.13,98.02 125.52,98.4 v2(125.52,98.47)
N28857240: length 1.2
  TOP w0.112: T15.1 126.15,98.49 v2(126.13,98.47)
  BOTTOM w0.102: UC1.AK12 125.78,98.13 126.12,98.47 v2(126.13,98.47)
N28861827: length 9.3
  BOTTOM w0.076: 93.47,117.24 93.92,117.24 95.2,115.96 95.2,115.02 96.02,114.2 96.02,112.61 96.11,112.52 UC1.C64
  BOTTOM w0.112: 93.47,117.24 v1(92.25,117.24) 92.22,117.24 91.78,117.68 RC120.1
N28938912: length 2
  TOP w0.112: v1(158.93,92.24) 158.63,91.95 CC8.1 RC29.2
N28938914: length 1.9
  TOP w0.112: v1(157.61,101.56) 157.54,101.62 RC28.2 156.62,102.49 CC7.1
N29708559: length 7.8
  BOTTOM w0.076: 132.53,90.57 132.09,91 131,91 130.83,91.18 130.83,91.5 UC1.AY4
  BOTTOM w0.102: 132.53,90.57 135.14,90.57 135.23,90.66 136.2,90.66 136.88,89.99 T126.1
N29708561: length 4.6
  BOTTOM w0.102: UC1.BB3 131.64,90.35 135.44,90.35 T127.1
N29708639: length 6.4
  BOTTOM w0.102: UC1.BB5 130.64,89.93 133.75,89.93 134.9,88.78 135.36,88.78 T130.1
N31877076: length 3.2
  TOP w0.112: v2(62.39,130.92) 62.52,130.8 LV1.1
  BOTTOM w0.107: JEDP1.21 61.25,132.07 v2(62.39,130.92)
N32590572: length 1.4
  TOP w0.112: CZ117.1 275.87,90.54 UZ4.12
N32592963: length 1.4
  TOP w0.112: UZ4.10 275.81,91.34 CZ118.1
N32594166: length 1.6
  TOP w0.112: CZ109.1 248.79,110.8 UZ2.12
N32595008: length 5.8
  TOP w0.112: UZ2.3 253.6,110.8 253.83,110.56 v1(253.83,108.76) 253.17,108.1 RZ70.2 RZ71.2
N32817808: length 1.3
  TOP w0.112: CZ113.1 155.34,59.94 UZ3.12
N32818355: length 3.6
  TOP w0.112: v1(161.92,59.94) RZ65.2 RZ64.2 159.79,59.62 159.23,59.62 158.92,59.94 UZ3.3
N32819772: length 1.3
  TOP w0.112: CZ121.1 209.77,51.39 UZ8.6
N33612393: length 2
  TOP w0.112: RD18.1 v1(116.1,54.38)
  TOP w0.508: CD31.2 RD18.1
N35551576: length 1.8
  TOP w0.254: PQ1209.2 PQ1209.3 30.95,125.98 PR1236.1
N35551581: length 1.2
  TOP w0.254: PR1229.2 28.78,122.97 29.05,123.24 PQ1209.6
N35551592: length 5.8
  TOP w0.112: PR1237.2 35.83,58.56 v1(35.71,58.56)
  TOP w0.203: PR1237.2 PC1212.1 PR1247.1 36.03,56.02 35.84,55.83 v2(35.84,55.26)
  BOTTOM w0.203: PU1201.6 36.42,54.74 35.9,55.26 v2(35.84,55.26)
N35551655: length 5.6
  TOP w0.112: v1(38.66,51.83) 39.66,52.83 PC1205.1
  TOP w0.203: PC1205.1 PR1217.1 PR1208.2 39.92,55.39 v2(40.29,55.39)
  BOTTOM w0.203: PU1201.2 v2(40.29,55.39)
N35551713: length 3.2
  TOP w0.254: PR1212.2 44.54,103.53 PQ1201.6
N35551785: length 4.3
  BOTTOM w0.112: PR1202.2 v1(43.38,109.92)
  BOTTOM w0.254: PQ1203.2 43.57,108.72 PR1202.2 43.12,108.65 42.34,108.65 PR1209.1
N35551806: length 1.1
  BOTTOM w0.254: PR1209.2 41.89,107.84 PQ1204.3
N35551822: length 1.1
  TOP w0.254: PQ1201.3 46.72,107.59 46.96,107.83 PR1213.2
N36307052: length 8.9
  TOP w0.076: UT5.F10 31.27,78.72 31.27,77.55 31.04,77.31
  TOP w0.112: RT97.2 v1(31.74,72.3) ; RT97.2 RT99.1 30.75,74.19 30.4,74.53 30.4,76.66 30.87,77.13 30.87,77.14 31.04,77.31 ; RT97.2 RT98.1
N36307117: length 3.8
  TOP w0.076: UT5.G4 31.02,82.38 v2(30.94,82.46)
  BOTTOM w0.112: RT85.1 29.79,83.48 v1(29.79,83.38) 29.91,83.26 30.69,83.26 30.94,83.02 v2(30.94,82.46)
N36307119: length 5.7
  TOP w0.076: UT5.F4 v2(31.52,82.46)
  BOTTOM w0.112: RT84.1 29.49,85.15 29.49,84.15 29.98,83.65 30.94,83.65 31.29,83.3 31.29,82.94 v1(31.31,82.92) 31.52,82.71 v2(31.52,82.46)
N36307669: length 3
  TOP w0.076: UT5.F1 31.72,83.68 31.72,84.26 31.81,84.35 31.81,84.46 31.8,84.47 31.8,84.51
  TOP w0.112: RT63.1 32.13,85.82 32.13,85.71 31.8,85.39 31.8,84.51
N36307918: length 3.3
  TOP w0.076: 27.93,78.18 28.36,78.18 28.9,78.72 29.27,78.72 UT5.K10
  TOP w0.112: 27.93,78.18 27.71,78.18 27.08,77.54 RT105.1
N36307920: length 3.1
  TOP w0.076: 27.93,78.74 28.23,78.74 28.7,79.22 29.27,79.22 UT5.K9
  TOP w0.112: RT104.1 27.02,78.74 27.93,78.74
N36307926: length 3.1
  TOP w0.076: 28.03,77.31 28.03,77.8 28.22,77.99 28.54,77.99 UT5.L11
  TOP w0.112: RT103.1 28.03,76.48 28.03,77.31
N36626863: length 3.3
  TOP w0.112: v2(22.01,66.48) v1(22.01,65.96)
  TOP w0.381: v2(22.01,66.48) CT90.1 RT111.2
  BOTTOM w0.381: v2(22.01,66.48) 22.01,66.8 21.87,66.94 UT7.3
N36736352: length 0.9
  BOTTOM w0.112: RT85.2 27.04,84.4 T220.1
N36736355: length 1
  BOTTOM w0.112: T219.1 28.66,87.83 RT84.2
N36827741: length 5
  TOP w0.112: UZ34.4 139.14,66.43 RZ120.2 ; UZ26.4 138.14,66.3 RZ120.2 ; v1(141.07,66.77) 139.67,66.77 139.47,66.57 139.47,66.51 RZ120.2
N38312012: length 3
  TOP w0.076: UT5.H7 30.26,80.73 v2(30.05,80.73)
  BOTTOM w0.112: v2(30.05,80.73) 29.55,80.73 CT87.1 28.26,79.44 v1(28.26,79.34)
N38327809: length 2.1
  TOP w0.076: v2(32.99,81.32) 32.86,81.32 UT5.D6
  BOTTOM w0.112: RT101.1 32.27,81.32 v2(32.99,81.32) 33.18,81.32 v1(33.56,80.94)
N38749366: length 3.1
  TOP w0.254: QV2.1 41.55,124.21 41.55,124.86 RV5.2
N38749387: length 4.4
  TOP w0.112: RV6.1 49.5,121.03 QV7.1 48.21,122.32 QV8.2
N39468508: length 1.9
  TOP w0.203: PC647.2 57.2,93.64 v1(57.2,92.75) 57.1,92.64 56.44,92.64 PR650.2
N39468570: length 2.7
  BOTTOM w0.112: PC629.2 53.24,96.9 53.24,97.55 v1(53.52,97.83)
  BOTTOM w0.203: PR639.1 PC629.2
N39469485: length 18.3
  TOP w0.254: PR610.1 v2(47.57,89.16)
  BOTTOM w0.254: PR631.2 48.28,90.43 47.57,89.72 v2(47.57,89.16) v1(48.35,88.39) 48.63,88.11 55.03,88.11 56.69,89.77 56.69,93.33 PH601.2
N39469718: length 1.9
  TOP w0.112: PR632.2 52.91,88.06 v1(53.03,87.93)
  TOP w0.254: PR632.2 52.04,88.91 PC627.1
N39469776: length 27
  TOP w0.203: v2(53.54,91.48) 54.1,91.48 PR635.1
  IN1 w0.254: v2(56.51,112.43) 56.37,112.43 55.37,111.43 55.37,102.14 53.97,100.75 53.97,98.38 52.81,97.21 52.81,92.11 53.44,91.48 v2(53.54,91.48)
  BOTTOM w0.203: PR647.2 53.22,91.48 v2(53.54,91.48)
  BOTTOM w0.254: v2(56.51,112.43) 57.48,112.43 PH603.2
N39469798: length 5.3
  TOP w0.254: v2(62.94,114.01) 63.22,114.01 63.46,114.25 63.46,115.52 62.89,116.09 v1(62.62,116.09) PR679.1
  BOTTOM w0.254: PU614.7 62.89,114.06 v2(62.94,114.01)
N39469812: length 3.4
  TOP w0.254: PR628.2 67.33,96.09 v2(67.14,95.9)
  BOTTOM w0.102: PH602.1 67.91,94.63 v3(68.41,94.12)
  BOTTOM w0.254: PH602.1 67.14,94.83 v2(67.14,95.9)
N39469818: length 1.9
  BOTTOM w0.112: PR630.2 48.21,97.62 48.36,97.78 v1(48.36,98.18)
  BOTTOM w0.203: PR630.2 PC631.1
N39469863: length 4.7
  TOP w0.203: PU602.28 49.14,98.07 v2(49.07,98.13)
  BOTTOM w0.112: v1(50,98.31) 49.25,98.31 v2(49.07,98.13)
  BOTTOM w0.203: PC632.1 48.12,99.38 PR636.1 48.98,98.83 49.07,98.74 v2(49.07,98.13)
N39469888: length 4.7
  TOP w0.112: v1(53.71,90.8) 52.91,90 PR638.2
  TOP w0.203: PC627.2 52.02,89.76 52.02,90.56 51.61,90.97 51.38,90.97 51.14,91.22 PU602.8
  TOP w0.254: PC627.2 52.04,89.8 PR638.2
N39469908: length 1.9
  TOP w0.112: v1(50.51,87.09) 50.25,87.35 PC617.2
  TOP w0.254: PC617.2 PR621.1
N39469972: length 3.4
  TOP w0.112: PU602.38 46.17,93.17 v2(46.09,93.25)
  BOTTOM w0.112: v2(46.09,93.25) v1(46.09,93.76) 46.9,94.58 PR678.2
N39469996: length 2.5
  TOP w0.112: v2(59.28,114.06) 58.82,114.06 v1(58.55,114.34)
  TOP w0.508: PC611.2 59.87,114.31 59.62,114.06 v2(59.28,114.06)
  BOTTOM w0.254: PU614.2 v2(59.28,114.06)
N39469998: length 1.2
  TOP w0.112: PC611.1 60.1,112.04 v1(59.84,111.78)
N39470055: length 3.6
  TOP w0.203: PU602.20 52.88,95.97 52.93,96.02 52.93,96.58 53.14,96.78 53.87,96.78 54.3,97.22 PC630.1 55.37,97.22 PR640.1
N39470129: length 2.7
  BOTTOM w0.112: PC640.1 51.3,100.61 51.3,101.33 v1(51.71,101.74)
  BOTTOM w0.203: PC640.1 50.77,100.28 PR646.2
N39470145: length 1.4
  BOTTOM w0.203: PR652.2 49.99,100.41 49.99,100.93 49.98,100.94 49.98,101.43 PC601.1
N39470169: length 0.9
  TOP w0.203: PC630.2 55.37,98.13 PR644.1
N39470173: length 1.8
  BOTTOM w0.112: v1(47.12,98.46) 47.19,98.54 PC632.2
  BOTTOM w0.203: PC632.2 PR641.1
N39470189: length 1.9
  BOTTOM w0.112: PR642.2 v1(70.76,119.78)
  BOTTOM w0.254: PR642.2 PH604.1
N39470248: length 2.1
  TOP w0.112: v1(49.1,87.08) 48.47,87.7 PR623.1
  TOP w0.254: PR623.1 47.55,88.01 PC621.2
N39470250: length 3.9
  TOP w0.203: PU602.5 49.93,90.99 49.53,90.59 49.53,89.98 PR622.2 49.35,88.94 PR621.2 PR623.2
N39470270: length 0.9
  BOTTOM w0.254: PH605.1 PR657.2
N39470326: length 4.2
  TOP w0.203: v2(49.07,90.43) 49.07,90.61 49.53,91.08 PU602.4
  BOTTOM w0.112: v2(49.07,90.43) v1(48.61,89.98)
  BOTTOM w0.203: v2(49.07,90.43) 49.07,91.49 PR617.2 49.16,92.25 PC616.2
N39470328: length 0.9
  BOTTOM w0.203: PC614.2 50.09,91.57 PR617.1
N39470344: length 2.2
  TOP w0.203: PR610.2 48.51,89.83 48.51,90.52 49.14,91.15 PU602.3
N39470375: length 4.2
  TOP w0.203: v2(47.33,90.5) 47.8,90.97 48.49,90.97 48.73,91.22 PU602.2
  BOTTOM w0.112: v2(47.33,90.5) v1(46.96,90.13)
  BOTTOM w0.203: v2(47.33,90.5) 47.4,90.56 PC613.2 PR613.2
N39470446: length 5.8
  TOP w0.203: v2(45.59,96.86) 45.52,96.78 45.19,96.78 PR602.1 45.59,96 45.59,95.85 46.67,94.77 PU602.34
  BOTTOM w0.102: v3(46.08,96.59) 45.86,96.59 v2(45.59,96.86)
  BOTTOM w0.203: v2(45.59,96.86) 45.33,96.59 PC603.1
N39470448: length 6.2
  TOP w0.203: PU602.33 46.83,95.17 46.18,95.82 46.18,96.92 v2(45.62,97.48) PR603.1
  BOTTOM w0.102: v1(45.81,98.31) 45.62,98.12 v2(45.62,97.48)
  BOTTOM w0.203: v2(45.62,97.48) 45.05,97.48 PC604.1
N39470528: length 3.1
  TOP w0.203: v2(46.63,96.02) 46.63,96 47.06,95.57 PU602.32
  BOTTOM w0.102: v1(46.06,95.07) 46.68,95.07 PR608.1
  BOTTOM w0.203: PR608.1 47.06,95.57 46.63,96 v2(46.63,96.02)
N39470532: length 3.1
  TOP w0.203: PU602.31 47.27,95.97 47.09,96.15 v2(47.09,97.88)
  BOTTOM w0.203: PR611.1 47.27,97.7 v2(47.09,97.88)
N39470546: length 0.9
  TOP w0.203: PC639.2 PR645.1
N39473183: length 3.5
  TOP w0.112: v2(64.67,107.39) v1(64.67,107.96)
  TOP w0.254: PR661.1 64.92,107.14 v2(64.67,107.39)
  BOTTOM w0.254: PL610.3 v2(64.67,107.39)
N39473185: length 1.4
  BOTTOM w0.112: PC671.2 v1(57.96,89.05)
N39473187: length 2
  BOTTOM w0.112: v1(61.75,87.51) 61.75,87.86 PR672.2
N39473189: length 1.2
  BOTTOM w0.112: PC671.1 v1(59.35,86.43)
N39473240: length 2.5
  BOTTOM w0.112: v1(59.6,96.48) PR671.1
  BOTTOM w0.203: PU612.1 60.1,94.51 59.6,95.01 PR671.1
N39473270: length 1.3
  BOTTOM w0.112: v1(53.9,111.8) 53.62,111.52 PC655.2
N39473272: length 2.5
  BOTTOM w0.112: v1(52.89,107.17) 52.98,107.26 52.98,108.79 PR660.2
N39473274: length 1.2
  BOTTOM w0.112: PR660.1 52.22,108.27 v1(52.2,108.24)
N39473308: length 3.1
  BOTTOM w0.112: v1(60.92,111.71) PR659.1
  BOTTOM w0.203: PU610.1 58.96,110.32 59.18,110.54 59.18,110.77 59.98,111.57 PR659.1
N40478997: length 1.3
  TOP w0.508: RV18.2 19.4,77.8 QV4.2
N41228182: length 4
  TOP w0.112: v2(231.74,106.17) 231.62,106.06 RZ326.1 231.05,106.36 230.34,107.07 v1(229.91,107.07)
  BOTTOM w0.102: JNGFF2.17 231.06,105.75 231.48,106.17 v2(231.74,106.17)
N41307615: length 1.9
  BOTTOM w0.112: v1(279.5,58.51) CZ38.2 RZ334.1
N44311288: length 3
  TOP w0.112: RE70.1 RE90.2 ; RE90.2 261.47,103.45 261.35,103.34 QE11.3 ; RE90.2 v1(261.95,104.4)
N44311298: length 2.7
  TOP w0.112: QE4.2 262.91,102.51 RE70.2 263.92,103.62 v1(263.92,103.66)
N44321668: length 9
  TOP w0.107: UE1.B1 247.48,83.58 246.56,82.66 246.56,78.2 RE58.1
  TOP w0.112: RE58.1 245.72,77.35 v1(245.72,76.8) 245.72,76.16 RE57.1
N44321726: length 10
  TOP w0.107: UE1.G2 251.87,84.28 251.87,82.5 v2(251.62,82.26)
  TOP w0.112: v2(250.54,77.71) 250.54,76.81 RE318.1
  IN3 w0.135: v2(250.54,77.71) 251.1,78.27 251.1,81.74 v2(251.62,82.26)
N44321827: length 7.6
  TOP w0.112: UE1.N4 257.28,86.26 258.35,85.18 v1(258.36,85.18) 258.36,84.32 259.04,83.64 261.69,83.64 RE349.2
N44321953: length 1.8
  TOP w0.112: v1(247.1,73.94) CE57.1 RE350.2
N44725169: length 3.5
  TOP w0.112: UZ8.3 204.89,51.39 CZ197.1 RZ345.2 203.61,51.37 v1(203.07,51.9)
N44905504: length 2.3
  BOTTOM w0.112: JDIMM1.162 118.48,51.47 T50.1
N44907662: length 3
  TOP w0.107: T51.1 v2(119.85,59.64)
  BOTTOM w0.112: JDIMM1.165 119.23,61.9 119.23,61.07 119.85,60.45 v2(119.85,59.64)
N45108671: length 1.8
  TOP w0.112: v2(231.57,95.25) 230.95,95.25 T225.1
  BOTTOM w0.112: JNGFF2.59 v2(231.57,95.25)
N45160305: length 7.5
  TOP w0.112: v2(248.48,53.71) v1(248.48,53.06)
  BOTTOM w0.112: JESPI.8 243.95,54.41 244.83,53.53 248.3,53.53 v2(248.48,53.71) 248.87,54.1 RE375.1
N45555545: length 2.4
  BOTTOM w0.112: v1(285.66,13.64) RZ25.1 285.84,12.41 QZ3.1
N45596940: length 2.6
  TOP w0.112: RE13.2 RE14.1 267.25,89.17 UE2.1
N45596942: length 6.1
  TOP w0.112: v1(265.26,87.07) 265.53,86.8 266.66,86.8 RE15.2 267.56,87.7 267.56,88.56 RE16.1 267.75,89.39 UE2.2
N45597032: length 2.8
  TOP w0.112: UE2.3 268.25,89.79 RE18.1 RE17.2
N46307245: length 2.4
  BOTTOM w0.112: CZ56.1 160.04,104.68 RZ63.1 159.99,104.35 159.88,104.24 v1(159.88,103.72)
N46307369: length 3.4
  BOTTOM w0.112: UZ12.29 155.16,110.22 RZ112.2 RZ362.2 v1(155.13,112.23)
N46307398: length 2.5
  BOTTOM w0.112: UZ12.27 155.76,109.22 155.61,109.37 RZ62.1 v1(155.13,108.29)
N46307584: length 5.4
  BOTTOM w0.112: RZ113.2 156.58,104.11 v1(156.29,104.11) 156.13,104.11 155.55,104.68 153.63,104.68 QZ9.2
N46398396: length 3.6
  TOP w0.112: RZ131.2 239.23,98.04 v2(239.52,97.75) 240.04,97.75 v1(240.32,98.03)
  BOTTOM w0.112: JNGFF2.48 239.27,98 v2(239.52,97.75)
N46398406: length 4.8
  TOP w0.112: v1(240.31,96.68) 239.84,97.15 v2(239.52,97.15) 239.09,97.59 238.24,97.59 RZ132.2
  BOTTOM w0.112: JNGFF2.50 239.17,97.5 v2(239.52,97.15)
N46553115: length 1.9
  TOP w0.112: QE12.1 246.31,102.81 247.08,103.58 RE94.1
N47658252: length 54.3
  TOP w0.112: v2(241.58,105.46) 241.46,105.34 RE536.1 RE537.2 ; v2(239.86,94.75) 239.91,94.7 v3(240.54,94.7) 241.98,94.7 RE348.1 ; RE348.1 242.67,96.48 242.49,96.66 UE7.3 ; RE348.1 RE34.2
  IN1 w0.119: v2(239.86,94.75) 239.86,94.35 239.53,94.02 239.1,94.02 238.77,94.35 238.77,98.68 239.92,99.84 239.92,102.28 241.58,103.94 v2(241.58,105.46) 241.58,105.58 243.92,107.92 243.92,111 241.29,113.64 v2(241.29,117.42)
  BOTTOM w0.112: QE13.1 239.48,132.55 239.01,132.08 239.01,127.35 238.34,126.68 238.34,125.21 241.55,121.99 241.55,117.69 v2(241.29,117.42)
N47658256: length 5.8
  BOTTOM w0.112: QE13.6 239.1,132.55 239.52,132.97 240.64,132.97 240.75,132.86 240.75,131.42 240.59,131.25 QE13.3 v1(240.25,130.03)
N47658366: length 2.6
  TOP w0.112: UE7.4 244.99,96.66 CE5.1 245.39,95.76 245.48,95.67 v1(245.48,95.06)
N119328643: length 5.1
  TOP w0.203: PU901.25 55.12,54.6 54.63,54.11 54.25,54.11 v2(53.92,53.78) 53.94,53.77 PR931.2
  BOTTOM w0.112: v2(53.92,53.78) v1(53.41,53.78)
  BOTTOM w0.254: v2(53.92,53.78) 53.86,53.85 PC938.1 PR930.1
N132000604: length 1.3
  TOP w0.112: v1(62.51,55.64) 62.19,55.95 PC934.1
N132005053: length 122.4
  TOP w0.254: v2(172.08,49.57) 171.96,49.69 171.96,51.78 172.21,52.03 PR917.3
  IN2 w0.254: v2(62.03,53.76) 62.03,54.01 62.25,54.24 62.91,54.24 63.35,53.81 64.44,53.81 65.33,54.7 68.59,54.7 70.74,52.55 70.74,51.5 71.91,50.33 138.96,50.33 142.44,53.05 146.64,53.05 148.38,54.78 158.21,54.78 163.14,49.85 170.76,49.85 170.97,50.05 171.78,50.05 172.08,49.74 v2(172.08,49.57)
  BOTTOM w0.112: v2(62.03,53.76) v1(62.03,53.17)
  BOTTOM w0.254: PR938.2 62.27,54.53 62.03,54.29 v2(62.03,53.76)
N4771653718: length 2.2
  TOP w0.203: PU901.27 55.92,54.37 55.52,53.97 v1(55.52,53.88) 55.52,53.17 PR932.1

## Copper pours and planes (outline as drawn)
2.5VSP on TOP (solid shape): 147.65,62.44 148.8,62.44 149,62.24 149,61.03 148.74,60.78 148.74,60.53 148.61,60.4 147.6,60.4 147.59,60.39 147.39,60.59 145.79,60.59 145.79,61.33 146,61.53 146,62.16 146.56,62.16 146.56,62.7 146,62.7 146,62.93 147.17,62.93
3V_SN on BOTTOM (solid shape): 162.01,71.89 162.33,71.58 163.22,71.58 163.22,70.94 161.44,70.94 161,71.38 161,72.97 162.01,72.97
3V_VIN on TOP (solid shape): 154.84,73.8 154.84,72.85 154.71,72.72 153,72.72 152.93,72.78 152.93,73.23 153,73.29 153.44,73.29 154.08,73.92 154.71,73.92
3V_VIN on BOTTOM (solid shape): 153.7,74.34 153.79,74.36 154.98,74.36 155.03,74.31 155.03,72.6 154.91,72.38 155.03,72.15 155.03,69.01 153.83,67.81 153.14,67.81 153.14,68.22 152.63,68.22 152.63,67.81 152.34,67.81 152.34,68.22 151.83,68.22 151.83,67.81 151.41,67.81 151.41,68.6 152.55,69.73 152.55,73.29 152.74,73.48 153.28,73.48 153.43,73.63 153.43,74.29 153.49,74.36 153.59,74.36
5V_SN on TOP (solid shape): 190.46,56.02 191.29,55.19 191.29,53.54 190.08,53.54 189.83,53.8 189.83,56.46 190.46,56.46
5V_VIN on BOTTOM (solid shape): 184.07,54.55 184.12,54.53 184.17,54.53 184.22,54.53 184.27,54.55 184.31,54.56 185.44,54.56 185.51,54.49 185.51,53.66 185.83,53.34 185.83,51.65 185.29,51.12 184.08,51.12 184,51.19 183.62,51.19 183.62,51.67 182.21,51.67 182.21,51.19 181.47,51.19 181.46,51.19 180.3,51.19 180.11,51.38 180.11,51.95 184.24,51.95 184.24,51.9 184.25,51.85 184.26,51.8 184.29,51.75 184.32,51.7 184.35,51.66 184.4,51.63 184.44,51.6 184.49,51.59 184.54,51.57 184.6,51.57 184.65,51.57 184.7,51.59 184.75,51.6 184.8,51.63 184.84,51.66 184.87,51.7 184.9,51.75 184.93,51.8 184.94,51.85 184.95,51.9 184.95,51.95 184.94,52.01 184.93,52.06 184.9,52.1 184.87,52.15 184.84,52.19 184.8,52.22 184.75,52.25 184.7,52.27 184.65,52.28 184.6,52.28 184.54,52.28 184.49,52.27 184.44,52.25 184.4,52.22 184.35,52.19 184.32,52.15 184.29,52.1 184.26,52.06 184.25,52.01 184.24,51.95 180.11,51.95 180.11,52.78 179.98,52.91 179.98,52.91 179.22,52.91 179.16,52.97 179.16,53.99 182.47,53.99 182.62,53.83 183.56,53.83 183.77,54.04 183.77,54.34 183.98,54.56 184.04,54.56
+0.6V_DDR_VTT on TOP (solid shape): 72.99,71.32 72.99,70.56 72.8,70.37 71.72,70.37 71.65,70.43 71.65,71.51 71.72,71.58 72.73,71.58
+0.6V_DDR_VTT on TOP (solid shape): 71.59,56.4 71.59,54.9 71.73,54.76 71.73,54.42 71.6,54.29 70.76,54.29 70.57,54.48 70.57,56.4 70.7,56.53 71.46,56.53
+0.6V_DDR_VTT on TOP (solid shape): 143.28,54.05 143.28,52.67 143.51,52.44 143.51,52 143.38,51.88 141.48,51.88 140.79,51.19 140.23,51.19 140,51.42 140,51.85 140.11,51.95 140.11,53.22 140.3,53.41 141.82,53.41 142.58,54.18 143.15,54.18
+0.6V_DDR_VTT on BOTTOM (solid shape): 142.65,54.54 142.65,52.84 142.8,52.69 143.33,52.69 143.48,52.54 143.48,51.98 143.38,51.88 142.31,51.88 142.17,52.02 142.17,52.69 142.31,52.84 142.31,54.54 142.37,54.6 142.59,54.6
+0.6V_DDR_VTT on IN3 (solid shape): 73.18,71.19 73.18,68.84 72.16,68.84 72.16,70.05 71.91,70.31 71.91,71.19 72.03,71.32 73.05,71.32
+0.6V_DDR_VTT on IN3 (solid shape): 72.77,56.37 72.31,55.92 70.69,55.92 70.53,56.07 70.53,56.91 70.71,57.08 71.58,57.08 71.78,57.29 71.78,57.54 72.77,57.54
+0.6VSP on BOTTOM (solid shape): 71.22,70.32 71.22,69.84 70.74,69.35 69.81,69.35 69.53,69.63 68.82,69.63 68.76,69.7 68.76,70.25 68.83,70.33 69.46,70.33 69.49,70.29 69.98,70.29 70.15,70.47 71.07,70.47
+0.6VSP on TOP: 71.46,71.27 71.46,71.51 71.4,71.58 70.33,71.58 70.1,71.35 70.1,70.5 69.87,70.27 69.87,69.05 70.09,68.83 70.89,68.83 70.89,69.73 71.46,70.31 71.46,70.74 71.44,70.76 70.9,70.76 70.9,71.27
+0.9V_LAN on TOP (solid shape): 244.4,124.57 244.4,124.06 244.34,124.01 242.8,124.01 242.77,124.04 242.77,124.6 242.82,124.65 244.32,124.65
+0.9V_LAN on TOP (solid shape): 248.18,123.43 248.18,122.48 248.42,122.24 249.36,122.24 249.51,122.09 249.51,121.66 249.4,121.55 248.71,121.55 248.69,121.55 247.98,122.27 247.98,123.43 248.03,123.48 248.13,123.48
+0.9V_LAN on TOP (solid shape): 246.99,123.43 246.99,122.26 247.09,122.16 247.09,122.14 247.45,121.78 247.45,121.76 247.47,121.66 247.53,121.58 247.63,121.48 247.77,121.44 247.79,121.44 247.88,121.35 247.88,121.14 247.72,120.99 247.27,120.99 247.09,121.17 247.09,121.8 246.76,122.13 246.76,123.43 246.81,123.48 246.94,123.48
+0.9V_LAN on BOTTOM (solid shape): 252.18,131.58 252.18,126.38 252.12,126.31 250.66,126.31 249.07,124.72 248.12,124.72 247.8,125.04 247.67,125.04 247.67,125.49 247.86,125.68 248.5,125.68 248.75,125.93 248.75,126.66 248.47,126.93 248.28,126.93 248.12,127.1 248.12,127.71 248.44,128.03 251.1,128.03 251.29,128.22 251.29,130.63 250.09,131.84 242.53,131.84 242.21,131.52 242.21,130 242.78,129.42 242.78,128.98 243.17,128.6 244.18,128.6 244.56,128.22 244.56,125.61 244.44,125.49 243.99,125.49 243.93,125.55 243.93,127.14 243.61,127.46 241.51,127.46 241.01,127.96 241.01,132.22 241.77,132.98 250.79,132.98
+0.9V_LAN on IN2 (solid shape): outline of 500 points within 242.28,120.98 248.88,129.58
