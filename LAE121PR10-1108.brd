# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UPD1_SMBCLK: length 270.2
  TOP w0.107: v2(247.88,85.06) UE1.C3
  TOP w0.112: v2(242,86.22) 241.8,86.42 241.32,86.42 RE303.1
  IN1 w0.119: v2(236.63,53.31) 236.8,53.14 236.8,52.7 236.55,52.45 230.2,52.45 229.54,53.11 218.86,53.11 218.38,52.63 210.51,52.63 208.55,50.67 188.91,50.67 186.46,53.12 186.46,55.66 185.27,56.86 180.24,56.86 179.48,57.62 173.46,57.62 170.04,61.04 163.25,61.04 160.93,63.35 157.17,63.35 156.66,62.84 148.05,62.84 146.66,64.24 146.66,66.7 145.47,67.89 87.29,67.89 76.88,78.31 57.56,78.31 56.79,77.54 44.73,77.54 42.01,80.27 40.83,80.27 40.16,80.94 v2(40.16,82.24) ; v2(242,86.22) 242.55,86.77 245.04,86.77 246.36,85.45 247.49,85.45 v2(247.88,85.06)
  BOTTOM w0.112: RT58.1 40.16,82.64 v2(40.16,82.24) 40.16,81.86 40.33,81.69 QT1.1 ; v2(236.63,53.31) 236.79,53.15 236.79,52.92 237.06,52.65 238.78,52.65 239.21,53.09 239.21,54.14 241.22,56.14 241.22,57.2 245.98,61.96 245.98,64.89 247.52,66.43 247.52,68.31 247.67,68.47 247.67,69.95 248.02,70.31 248.74,70.31 249.77,71.34 249.77,73.42 249.13,74.06 249.13,75.51 250.16,76.54 250.16,79.92 248.77,81.31 248.77,82.61 246.64,84.74 246.64,85.28 246.81,85.44 247.5,85.44 v2(247.88,85.06)
UPD1_SMBCLK_Q: length 27.7
  TOP w0.076: UT5.B5 33.77,81.72 34.21,81.72 34.34,81.6 35.11,81.6
  TOP w0.112: 35.11,81.6 36.8,81.6 36.9,81.69 37.38,81.69 v2(37.68,81.99) 37.68,82.61 RT67.1 ; v2(24.77,84.81) 24.94,84.98 25.15,84.98 RT92.1
  IN1 w0.119: v2(24.77,84.81) 24.94,84.98 26.52,84.98 27.07,84.42 29.11,84.42 29.87,83.66 33.76,83.66 35.03,84.92 37.19,84.92 37.62,84.49 37.62,82.84 38.13,82.33 38.13,81.9 38.03,81.8 37.87,81.8 v2(37.68,81.99)
  BOTTOM w0.102: v3(38.19,83.89) 39,83.08 RT58.2
  BOTTOM w0.112: QT1.6 37.98,81.69 v2(37.68,81.99) 38.25,82.56 38.68,82.56 RT58.2
UPD1_SMBDAT: length 269.1
  TOP w0.112: RE302.1 241.62,86.66 241.86,86.66 v2(242,86.8) ; UE1.B4 v2(247.08,85.86)
  IN1 w0.119: v2(242,86.8) 242.03,86.77 242.2,86.77 242.45,87.01 245.14,87.01 246.46,85.7 246.92,85.7 v2(247.08,85.86) ; v2(39.39,80.02) 41.91,80.02 44.63,77.3 56.9,77.3 57.66,78.06 76.78,78.06 87.19,67.65 145.36,67.65 146.41,66.6 146.41,64.14 147.95,62.6 156.76,62.6 157.27,63.11 160.83,63.11 163.14,60.79 169.93,60.79 173.36,57.37 179.37,57.37 180.14,56.61 185.16,56.61 186.21,55.56 186.21,53.02 188.81,50.42 208.65,50.42 210.61,52.38 218.48,52.38 218.96,52.86 229.44,52.86 230.1,52.21 236.65,52.21 237.05,52.6 237.05,53.14 v2(237.22,53.31)
  BOTTOM w0.112: v1(37.77,79.72) 37.77,80.03 38.12,80.39 QT1.4 39.03,80.39 v2(39.39,80.02) 39.39,79.87 39,79.47 RT59.1 ; v2(247.08,85.86) 246.91,85.68 246.71,85.68 246.4,85.38 246.4,84.64 248.53,82.51 248.53,81.21 249.92,79.82 249.92,76.64 248.89,75.61 248.89,73.96 249.53,73.32 249.53,71.44 248.64,70.54 247.93,70.54 247.44,70.05 247.44,68.57 247.28,68.41 247.28,66.53 245.74,64.99 245.74,62.06 240.98,57.3 240.98,56.24 238.97,54.24 238.97,53.19 238.68,52.89 237.16,52.89 237.03,53.02 237.03,53.12 v2(237.22,53.31)
UPD1_SMBDAT_Q: length 30.9
  TOP w0.076: 35.11,81.35 34.28,81.35 34.16,81.47 UT5.A5
  TOP w0.112: RT66.1 38.51,82.18 v2(37.68,81.35) 35.11,81.35 ; v2(24.77,85.39) 24.94,85.22 25.15,85.22 RT93.1
  IN1 w0.119: v2(24.77,85.39) 24.94,85.22 26.62,85.22 27.18,84.67 29.21,84.67 29.97,83.91 33.66,83.91 34.92,85.17 37.29,85.17 37.87,84.59 37.87,82.94 38.38,82.43 38.38,81.8 38.13,81.55 37.88,81.55 v2(37.68,81.35)
  BOTTOM w0.112: QT1.3 39.91,79.83 RT59.2 39.91,79.34 39.46,78.88 38.23,78.88 38.01,79.09 37.67,79.09 37.41,79.35 37.41,81.09 v2(37.68,81.35)
UPD1_SMBUS_ALERT#: length 3.7
  TOP w0.076: 35.11,80.72 34.89,80.72 34.77,80.61 34.29,80.61 34.17,80.72 33.77,80.72 UT5.B6
  TOP w0.112: RT68.1 RT60.2 35.95,80.72 35.11,80.72
UPD2_ALERT#: length 13.5
  TOP w0.107: UE1.F5 v2(250.28,86.66)
  TOP w0.112: RE92.1 250.19,75.08 v2(250.19,75.63)
  IN1 w0.119: v2(250.19,75.63) 251.05,76.49 251.05,80.34 250.68,80.71 250.68,86.26 v2(250.28,86.66)
UPD2_SMBCLK: length 14.4
  TOP w0.107: UE1.D7 v2(248.68,88.26)
  TOP w0.112: v2(260.08,89.75) 260.25,89.58 260.47,89.58 260.7,89.8 261.06,89.8 261.19,89.93 RPE12.3
  IN3 w0.135: v2(248.68,88.26) 248.96,88.54 248.96,88.74 249.27,89.05 256.33,89.05 256.43,88.95 258.32,88.95 258.96,89.59 259.92,89.59 v2(260.08,89.75)
UPD2_SMBDAT: length 14
  TOP w0.107: UE1.E7 v2(249.48,88.26)
  TOP w0.112: RPE12.4 261.2,89.43 261.07,89.56 260.8,89.56 260.57,89.34 260.25,89.34 v2(260.08,89.16)
  IN3 w0.135: v2(260.08,89.16) 259.92,89.33 259.06,89.33 258.43,88.69 256.32,88.69 256.22,88.78 249.38,88.78 249.22,88.63 249.22,88.52 v2(249.48,88.26)
USB2_ID: length 20.3
  IN2 w0.124: v2(133.67,100.13) 133.69,100.15 134.78,100.15 136.7,102.07 136.7,102.37 138.39,104.06 138.39,106.57 136.19,108.77 v2(136.19,110.94)
  BOTTOM w0.076: v2(133.67,100.13) 133.04,99.5 131.42,99.5 UC1.AG3
  BOTTOM w0.112: v2(136.19,110.94) v1(137.69,112.44) RC337.1
USB2_VBUSSENSE: length 20.9
  IN2 w0.124: v2(130.99,100.05) 131.62,100.69 134.99,100.69 136.47,102.17 136.47,102.46 138.16,104.15 138.16,106.48 135.91,108.73 135.91,110.53 135.61,110.83 v2(135.61,110.94)
  BOTTOM w0.076: UC1.AG4 130.99,99.72 v2(130.99,100.05) ; v2(135.61,110.94) v1(136.34,111.67) 136.8,112.14 RC338.1
USB3_PRX_DTX_N1: length 202.5
  TOP w0.104: JUSB1.5 285.87,82.14 285.72,82 285.31,82 284.83,81.52 283.62,81.52 283.08,82.06 283.08,83.13 282.27,83.93 281,83.93 280.86,84.07 DI4.9 DI4.1 279.28,84.07 279.13,83.92 277.07,83.92 271.11,77.96 266.92,77.96 263.79,74.83 v4(260.68,74.83) 258.24,74.83 257.52,74.12 255.58,74.12 254.75,73.29 249.17,73.29 248.9,73.56 245.85,73.56 244.92,74.48 240.87,74.48 239.99,73.61 238.07,73.61 v2(237.91,73.78)
  IN3 w0.076: v2(127.47,108.81) 127.56,108.81 127.66,108.91 127.66,109.1 127.54,109.22 127.41,109.22 127.35,109.28 127.18,109.28 127.1,109.2 127.1,108.04 127.28,107.86 128.6,107.86 128.76,108.02 128.99,108.02
  IN3 w0.135: v2(237.91,73.78) 237.72,73.58 236.52,73.58 236.03,73.09 236.03,70.77 235.12,69.86 234.7,69.86 232.57,67.73 231.48,67.73 231.32,67.89 229.3,67.89 224.78,63.37 203.54,63.37 202.65,64.25 195.81,64.25 arc(183.91,66.61) 173.82,73.35 173.23,73.95 arc(165.37,85.71) 162.61,99.58 162.61,102.65 160.56,104.7 159.14,104.7 158.54,105.3 151.19,105.3 148.9,107.58 147.95,107.58 146.86,108.67 139.5,108.67 139.23,108.94 135.5,108.94 135.01,108.46 129.88,108.46 129.44,108.02 128.99,108.02
  BOTTOM w0.102: UC1.H8 v2(127.47,108.81)
USB3_PRX_DTX_N2: length 177
  TOP w0.104: v2(235.7,104.95) 235.54,104.79 235.08,104.79 234.75,105.11 LI16.4 234.61,105.1 RI28.1
  IN3 w0.135: v2(235.7,104.95) 235.74,104.91 236.38,104.91 236.65,104.64 236.65,101.24 232.8,97.38 232.8,79.28 235.44,76.64 235.44,70.82 234.92,70.3 234.52,70.3 232.8,68.57 229.36,68.57 224.61,63.82 203.86,63.82 202.91,64.78 195.4,64.78 arc(184.04,67.04) 174.42,73.47 173.41,74.47 arc(165.76,85.92) 163.08,99.42 163.08,102.84 160.66,105.26 159.2,105.26 158.72,105.74 153.41,105.74 151.12,108.02 148.14,108.02 147.04,109.11 140.07,109.11 139.79,109.4 130.2,109.4 129.09,108.3 v2(128.4,108.3)
  BOTTOM w0.102: UC1.J6 128.76,107.98 128.41,108.22 v2(128.4,108.3)
USB3_PRX_DTX_N3: length 151.2
  TOP w0.104: JUSB2.5 14.33,59.18 14.51,59.35 14.89,59.35 15.67,60.14 16.87,60.14 17.5,60.76 17.5,61.97 18,62.47 18.79,62.47 18.94,62.32 DI1.9 DI1.1 20.55,62.32 20.7,62.47 v4(22.25,62.47) 23.61,62.47 24.53,63.39 24.66,63.39 v2(24.84,63.21)
  IN1 w0.076: v2(126.55,108.23) 126.32,108.47 126.23,108.47 126.16,108.39 126.16,107.96 125.88,107.68 125.33,107.68 124.69,108.32 124.27,108.32 124.25,108.3 124.23,108.3
  IN1 w0.119: 124.23,108.3 120.03,108.3 119.47,107.74 119.47,106.08 119.04,105.65 118.36,105.65 118.07,105.94 115.78,105.94 115.06,106.67 97.25,106.67 96.87,107.04 92.51,107.04 89.83,104.36 80.25,104.36 74.57,98.69 74.57,91.02 70.51,86.96 61.29,86.96 60.73,87.51 56.21,87.51 55.51,88.21 43.09,88.21 42.97,88.33 41.13,88.33 40.52,88.94 39.67,88.94 39.37,88.65 39.37,86.68 38.58,85.89 38.58,83.68 39.05,83.21 39.05,81.47 36.42,78.84 36.42,75.29 31.39,70.26 31.39,69.05 25.74,63.4 25.02,63.4 v2(24.84,63.21)
  BOTTOM w0.102: UC1.J10 v2(126.55,108.23)
USB3_PRX_DTX_P1: length 202.6
  TOP w0.104: v2(237.91,73.19) 238.13,73.41 240.08,73.41 240.95,74.28 244.84,74.28 245.77,73.36 248.82,73.36 249.08,73.09 254.84,73.09 255.66,73.92 257.6,73.92 258.32,74.63 260.35,74.63 260.38,74.6 261.04,74.6 261.07,74.63 263.88,74.63 267,77.76 271.19,77.76 277.15,83.72 279.13,83.72 279.28,83.57 DI4.2 DI4.8 280.86,83.57 281.03,83.73 282.19,83.73 282.88,83.04 282.88,81.98 283.54,81.32 284.91,81.32 285.39,81.8 285.76,81.8 285.87,81.69 JUSB1.6
  IN3 w0.076: 128.99,107.78 128.78,107.78 128.67,107.68 127.21,107.68 126.92,107.96 126.92,109.28 127.1,109.46 127.43,109.46 127.43,109.46 v2(127.55,109.58)
  IN3 w0.135: v2(237.91,73.19) 237.76,73.34 236.62,73.34 236.27,72.99 236.27,70.67 235.22,69.61 234.8,69.61 232.64,67.45 231.42,67.45 231.22,67.65 229.4,67.65 224.88,63.12 203.44,63.12 202.55,64.01 195.81,64.01 arc(183.82,66.39) 173.65,73.18 173.06,73.78 arc(165.15,85.62) 162.37,99.58 162.37,102.55 160.46,104.46 159.04,104.46 158.44,105.06 151.09,105.06 148.8,107.34 147.85,107.34 146.76,108.43 139.4,108.43 139.12,108.7 135.6,108.7 135.11,108.21 129.98,108.21 129.54,107.78 128.99,107.78
  BOTTOM w0.102: UC1.G8 127.84,109.29 v2(127.55,109.58)
USB3_PRX_DTX_P2: length 177
  TOP w0.104: RI27.1 234.61,104.21 LI16.1 234.73,104.21 235.1,104.59 235.52,104.59 235.7,104.4 v2(235.7,104.34)
  IN3 w0.135: v2(128.36,108.91) 128.36,108.81 128.48,108.69 128.56,108.69 128.72,108.54 128.99,108.54 130.1,109.64 130.53,109.64 130.72,109.83 131.1,109.83 131.29,109.64 131.68,109.64 131.86,109.83 132.25,109.83 132.44,109.64 139.89,109.64 140.17,109.35 147.14,109.35 148.24,108.26 151.22,108.26 153.51,105.98 158.82,105.98 159.3,105.5 160.76,105.5 163.32,102.94 163.32,99.42 arc(165.99,86.01) 173.58,74.64 174.59,73.64 arc(184.14,67.26) 195.4,65.02 203.01,65.02 203.96,64.06 224.51,64.06 229.26,68.81 232.7,68.81 234.42,70.54 234.82,70.54 235.2,70.92 235.2,76.54 232.56,79.18 232.56,97.48 236.41,101.34 236.41,104.54 236.28,104.67 236.03,104.67 235.7,104.34 v2(235.7,104.34)
  BOTTOM w0.102: v2(128.36,108.91) 128.64,108.64 UC1.H6
USB3_PRX_DTX_P3: length 151.2
  TOP w0.104: JUSB2.6 14.33,59.74 14.53,59.55 14.8,59.55 15.59,60.34 16.79,60.34 17.3,60.84 17.3,62.05 17.92,62.67 18.78,62.67 18.93,62.82 DI1.8 DI1.2 20.55,62.82 20.7,62.67 21.93,62.67 21.96,62.7 22.54,62.7 22.56,62.67 23.53,62.67 24.45,63.59 24.63,63.59 v2(24.84,63.8)
  IN1 w0.076: v2(126.55,108.88) 126.32,108.64 126.16,108.64 125.98,108.46 125.98,108.04 125.8,107.86 125.4,107.86 124.76,108.5 124.27,108.5 124.25,108.52 124.23,108.52
  IN1 w0.119: 124.23,108.52 119.94,108.52 119.25,107.83 119.25,106.17 118.95,105.87 118.45,105.87 118.16,106.16 115.87,106.16 115.15,106.88 97.34,106.88 96.97,107.26 92.41,107.26 89.74,104.58 80.16,104.58 74.35,98.78 74.35,91.11 70.42,87.17 61.38,87.17 60.82,87.73 56.3,87.73 55.6,88.43 43.18,88.43 43.06,88.55 41.22,88.55 40.61,89.15 39.57,89.15 39.16,88.74 39.16,86.77 38.36,85.98 38.36,83.59 38.84,83.12 38.84,81.56 36.2,78.93 36.2,75.38 31.17,70.35 31.17,69.14 25.65,63.62 25.02,63.62 v2(24.84,63.8)
  BOTTOM w0.102: UC1.H10 v2(126.55,108.88)
USB3_PRX_L_DTX_N2: length 3.3
  TOP w0.104: v2(231.74,104.84) 231.92,104.66 232.32,104.66 LI16.3 233.23,105.11 RI28.2
  BOTTOM w0.104: JNGFF2.21 231.11,104.75 231.23,104.63 231.53,104.63 v2(231.74,104.84)
USB3_PRX_L_DTX_P2: length 3.2
  TOP w0.104: v2(231.74,104.21) 231.99,104.46 232.36,104.46 232.61,104.21 LI16.2 233.23,104.21 RI27.2
  BOTTOM w0.104: v2(231.74,104.21) 231.51,104.43 231.26,104.43 231.07,104.25 JNGFF2.23
USB3_PTX_C_DRX_N1: length 13.6
  TOP w0.104: JUSB1.8 285.87,76.23 285.65,76.01 285.42,76.01 284.76,76.67 283.73,76.67 283.08,77.32 283.08,78.61 283.11,78.64 283.11,79.21 283.08,79.24 283.08,81 v4(282.39,81.69) 281.67,82.41 281.05,82.41 280.89,82.57 DI4.7 DI4.4 279.28,82.57 279.13,82.42 278.85,82.42 278.84,82.41 278.45,82.41 CI13.1
USB3_PTX_C_DRX_N2: length 2.8
  TOP w0.104: RI30.1 229.89,100.77 LI17.1 229.89,100.18 230.24,99.83 230.24,99.6 230.21,99.57 230.21,98.97 230.24,98.94 230.24,98.67 CI29.1
USB3_PTX_C_DRX_N3: length 9.5
  TOP w0.104: CI5.1 21.8,64.1 21.47,64.1 21.44,64.07 20.9,64.07 20.8,63.97 20.47,63.97 20.32,63.82 DI1.4 DI1.7 18.94,63.82 18.79,63.97 v4(18.15,63.97) 17.68,63.97 17.07,64.58 15.56,64.58 14.8,65.34 14.53,65.34 14.33,65.15 JUSB2.8
USB3_PTX_C_DRX_P1: length 13.7
  TOP w0.104: JUSB1.9 285.87,75.61 285.67,75.81 285.34,75.81 284.68,76.46 283.65,76.46 282.88,77.23 v4(282.88,78.93) 282.88,80.92 282.47,81.33 282.43,81.33 282.02,81.73 282.02,81.77 281.59,82.21 281.03,82.21 280.89,82.07 DI4.6 DI4.5 279.28,82.07 279.13,82.22 278.93,82.22 278.92,82.21 278.45,82.21 CI16.1
USB3_PTX_C_DRX_P2: length 2.7
  TOP w0.104: CI30.1 230.44,98.67 v4(230.44,99.29) 230.44,99.83 230.79,100.18 LI17.4 230.79,100.77 RI29.1
USB3_PTX_C_DRX_P3: length 9.5
  TOP w0.104: CI4.1 21.78,64.3 v4(21.16,64.3) 20.85,64.3 20.72,64.17 20.5,64.17 20.35,64.32 DI1.5 DI1.6 18.96,64.32 18.81,64.17 18.46,64.17 18.44,64.2 17.74,64.2 17.16,64.78 15.65,64.78 14.88,65.54 14.53,65.54 14.33,65.74 JUSB2.9
USB3_PTX_DRX_N1: length 196.1
  TOP w0.104: CI13.2 276.84,82.41 276.45,82.41 271.37,77.33 267.15,77.33 263.91,74.09 260.45,74.09 259.59,73.24 256.89,73.24 256.22,72.57 249.02,72.57 248.64,72.95 245.23,72.95 244.31,73.86 241.51,73.86 239.09,71.44 239.09,71.44 235.34,71.44 235.2,71.31 234.83,71.31 v2(234.56,71.58)
  IN3 w0.135: v2(234.56,71.58) 234.56,71.54 234.43,71.41 234.39,71.41 234.21,71.23 232.64,71.23 232.24,71.63 230.69,71.63 223.83,64.76 204.29,64.76 203.35,65.7 195.4,65.7 arc(184.4,67.89) 175.07,74.12 174.06,75.13 arc(166.62,86.27) 164,99.42 164,103.24 161.06,106.18 160.54,106.18 159.47,107.25 158.19,107.25 156.16,109.27 153.39,109.27 151.5,111.17 150.84,111.17 147.27,114.74 145.45,114.74 143.36,116.83 140.22,116.83 139.35,115.96 131.28,115.96 129.82,114.5 126.41,114.5 126.21,114.69 126.21,114.87 126.33,114.99 126.33,115.08 126.42,115.16 v2(126.49,115.16)
  BOTTOM w0.076: v2(126.49,115.16) 126.33,115 126.33,114.46 125.77,113.91 125.42,113.91 125.02,113.51 125.02,113.21 125.07,113.11 125.07,112.91 125.02,112.75 125.02,112.58 125.06,112.45 125.19,112.32 125.46,112.32 125.61,112.18 125.61,111.93 125.53,111.86 125.44,111.86 UC1.C13
USB3_PTX_DRX_N2: length 172.3
  TOP w0.104: CI29.2 230.15,97.15 230.15,96.73 230.53,96.34 v2(231.91,96.34)
  IN3 w0.135: v2(128.24,116.6) 128.13,116.6 127.96,116.77 127.96,117.32 128.1,117.46 139.03,117.46 139.69,118.11 149.98,118.11 159.23,108.86 161.51,108.86 163.84,106.53 163.84,105.68 165.12,104.4 165.12,99.42 arc(167.65,86.7) 174.86,75.92 175.8,74.98 arc(180.01,71.52) 184.81,68.96 arc(190.08,67.36) 195.56,66.82 203.96,66.82 204.87,65.91 220.45,65.91 223.07,68.54 225.82,68.54 228.43,71.16 228.43,72.29 229.22,73.07 231.38,73.07 232.49,74.19 232.49,77.97 230.91,79.55 230.91,96.4 231.13,96.63 231.72,96.63 231.91,96.44 v2(231.91,96.34)
  BOTTOM w0.076: UC1.B13 125.34,112.66 126.06,113.38 126.06,113.48 127.92,115.34 127.92,116.29 v2(128.24,116.6)
USB3_PTX_DRX_N3: length 181.2
  TOP w0.104: CI5.2 23.38,64.1 23.61,64.1 v2(23.79,63.92)
  IN3 w0.135: v2(23.79,63.92) 23.97,64.1 24.36,64.1 25.11,64.86 25.11,75.41 29.5,79.79 29.5,85.13 32.44,88.06 32.44,88.39 33.58,89.53 34.08,89.53 35.35,90.8 35.35,91.49 39.87,96.01 40.22,96.01 40.66,96.46 40.66,98.72 40.55,98.83 40.55,101.8 41.41,102.67 41.41,108.1 39.62,109.9 37.79,109.9 34.9,112.79 34.9,121.42 38.92,125.44 40.38,125.44 40.58,125.24 46.28,125.24 48.17,127.13 67.77,127.13 68.08,127.44 72.58,127.44 73.17,126.85 74.1,126.85 74.79,126.16 81.17,126.16 83.03,128.03 85.06,128.03 85.55,128.51 85.55,129.14 87.16,130.75 103.78,130.75 105.95,128.57 108.16,128.57 108.48,128.89 116.76,128.89 118.57,127.09 121.17,127.09 122.4,125.86 122.4,124 122.06,123.66 122.06,122.88 122.31,122.63 122.57,122.63 v2(122.76,122.44)
  BOTTOM w0.076: 124.73,117.61 124.73,117.59 124.71,117.58 124.71,114.79 124.36,114.45 124.36,113.18 124.18,112.99 124,112.99 123.94,112.92 UC1.B15
  BOTTOM w0.104: v2(122.76,122.44) 122.73,122.46 122.49,122.46 122.32,122.3 122.32,120.11 122.81,119.62 122.85,119.62 123.26,119.22 123.26,119.18 124.73,117.71 124.73,117.61
USB3_PTX_DRX_P1: length 196
  TOP w0.104: CI16.2 276.84,82.21 276.53,82.21 271.45,77.13 267.23,77.13 264,73.89 260.53,73.89 259.68,73.04 256.98,73.04 256.31,72.37 248.94,72.37 248.56,72.75 245.14,72.75 244.23,73.66 241.59,73.66 239.17,71.24 235.42,71.24 235.29,71.11 234.68,71.11 v2(234.56,70.99)
  IN3 w0.135: v2(234.56,70.99) 232.54,70.99 232.14,71.38 230.79,71.38 223.93,64.52 204.19,64.52 203.25,65.46 195.4,65.46 arc(184.3,67.67) 174.9,73.95 173.89,74.96 arc(166.39,86.18) 163.76,99.42 163.76,103.14 160.96,105.94 160.44,105.94 159.37,107.01 158.09,107.01 156.06,109.03 153.29,109.03 151.4,110.93 150.74,110.93 147.17,114.49 145.35,114.49 143.26,116.59 140.32,116.59 139.45,115.72 131.38,115.72 129.92,114.26 126.31,114.26 125.91,114.66 v2(125.91,115.16)
  BOTTOM w0.076: UC1.D13 125.07,111.69 124.99,111.96 124.99,112.07 124.85,112.55 124.85,112.8 124.89,112.89 124.89,113.08 124.89,113.08 124.85,113.17 124.85,113.58 125.35,114.08 125.7,114.08 126.15,114.53 126.15,114.92 v2(125.91,115.16)
USB3_PTX_DRX_P2: length 172.4
  TOP w0.104: CI30.2 230.68,97.41 230.35,97.07 230.35,96.81 230.62,96.54 231.4,96.54 v2(231.88,97.02)
  IN3 w0.135: v2(127.54,116.71) 127.72,116.89 127.72,117.42 128,117.7 138.93,117.7 139.59,118.35 150.08,118.35 159.33,109.1 161.61,109.1 164.08,106.63 164.08,105.78 165.36,104.5 165.36,99.42 arc(167.87,86.8) 175.03,76.09 175.97,75.15 arc(180.14,71.73) 184.9,69.18 arc(190.12,67.6) 195.56,67.06 204.06,67.06 204.97,66.15 220.35,66.15 222.97,68.78 225.72,68.78 228.19,71.26 228.19,72.39 229.12,73.32 231.28,73.32 232.25,74.29 232.25,77.87 230.67,79.45 230.67,96.5 231.03,96.87 231.72,96.87 231.73,96.88 231.74,96.88 v2(231.88,97.02)
  BOTTOM w0.076: v2(127.54,116.71) 127.75,116.51 127.75,115.42 125.89,113.55 125.89,113.46 125.46,113.03 125.31,113.03 125.23,113.1 125.23,113.26 UC1.A13
USB3_PTX_DRX_P3: length 181.2
  TOP w0.104: CI4.2 23.41,64.3 23.55,64.3 v2(23.79,64.53)
  IN3 w0.135: v2(23.79,64.53) 23.97,64.34 24.26,64.34 24.87,64.96 24.87,75.51 29.26,79.89 29.26,85.23 32.2,88.16 32.2,88.49 33.48,89.77 33.98,89.77 35.11,90.9 35.11,91.59 39.77,96.25 40.12,96.25 40.42,96.56 40.42,98.62 40.31,98.73 40.31,101.9 41.17,102.77 41.17,108 39.52,109.66 37.69,109.66 34.66,112.69 34.66,121.52 38.82,125.68 40.48,125.68 40.68,125.48 46.18,125.48 48.07,127.37 67.67,127.37 67.98,127.68 72.68,127.68 73.27,127.09 74.2,127.09 74.89,126.41 81.07,126.41 82.93,128.27 84.96,128.27 85.3,128.61 85.3,129.24 87.06,130.99 103.88,130.99 106.05,128.81 108.06,128.81 108.38,129.14 116.86,129.14 118.67,127.33 121.27,127.33 122.64,125.96 122.64,123.9 122.3,123.56 122.3,122.98 122.41,122.87 122.61,122.87 v2(122.76,123.02)
  BOTTOM w0.076: 124.53,117.61 124.53,117.59 124.54,117.58 124.54,114.87 124.19,114.52 124.19,113.25 124.11,113.17 124,113.17 123.94,113.23 UC1.A15
  BOTTOM w0.104: 124.53,117.61 124.53,117.62 v4(122.89,119.26) 122.12,120.03 122.12,122.38 v2(122.76,123.02)
USB3_PTX_L_DRX_N2: length 5.9
  TOP w0.104: RI30.2 229.89,101.69 LI17.2 229.89,102.63 229.96,102.7 229.96,103.09 230.38,103.51 v4(230.67,103.51) 230.93,103.51 231.23,103.21 v2(232.24,103.21)
  BOTTOM w0.104: v2(232.24,103.21) 232.21,103.25 JNGFF2.27
USB3_PTX_L_DRX_P2: length 5.9
  TOP w0.104: v2(231.91,102.71) 231.91,102.91 231.81,103.01 231.14,103.01 230.88,103.27 230.43,103.27 230.16,103.01 230.16,102.78 230.24,102.7 230.67,102.7 230.79,102.58 LI17.3 230.79,101.69 RI29.2
  BOTTOM w0.104: v2(231.91,102.71) 231.57,103.05 231.27,103.05 230.97,102.75 JNGFF2.29
USB20_N1: length 207.7
  TOP w0.104: UI3.2 277.01,77.69 276.86,77.84 276.86,77.96 v2(277.06,78.16)
  IN3 w0.135: v2(128.04,101.73) 127.7,101.39 127.7,101.38 127.37,101.06 126.57,101.06 126.35,100.84 126.35,100.48 126.62,100.21 130.24,100.21 130.81,99.64 131.86,99.64 132.4,99.11 134.59,99.11 134.67,99.19 140.7,99.19 141.94,100.43 142.87,100.43 143.45,101 144.23,101 144.6,101.36 145.99,101.36 146.64,100.71 149.41,100.71 150.84,99.28 150.84,93.52 153.26,91.1 153.26,88.66 151.45,86.85 151.45,84.88 149.47,82.9 149.47,72.92 151.97,70.42 160.14,70.42 163.78,66.78 178.55,66.78 179.66,66.14 arc(187.02,63.11) 194.91,62.08 201.59,62.08 202.45,61.23 213.47,61.23 214.1,60.59 217.28,60.59 217.59,60.91 226.74,60.91 229.03,58.62 233.54,58.62 236.06,56.1 240.58,56.1 245.5,61.02 245.5,61.87 248.98,65.35 248.98,67 249.62,67.64 249.62,68.97 253.02,72.38 255.89,72.38 258.95,75.44 260.86,75.44 262,76.57 262,77.95 262.98,78.93 263.8,78.93 265.17,80.3 267.5,80.3 268.78,79.01 276.7,79.01 276.96,78.75 276.96,78.26 v2(277.06,78.16)
  BOTTOM w0.089: v2(128.04,101.73) 128.04,101.83 UC1.AB9
USB20_N1_R: length 11.8
  BOTTOM w0.104: LI7.2 278.88,74.26 279.03,74.41 279.41,74.41 279.68,74.67 v4(279.68,74.92) 279.68,75.33 279.99,75.64 279.99,76.19 280.55,76.76 DI5.2 280.77,76.92 280.17,77.52 280.17,77.67 280.78,78.28 280.78,79.28 281.17,79.67 281.92,79.67 281.94,79.69 282.3,79.69 282.84,79.16 283.94,79.16 284.37,78.73 JUSB1.2
USB20_N2: length 147.2
  IN1 w0.119: v2(129.99,100.62) 129.78,100.41 129.78,100.2 129.54,99.96 125.07,99.96 124.95,100.07 119.19,100.07 118.82,99.71 118.82,98.87 117.1,97.15 117.1,93.31 115.46,91.66 107.93,91.66 106.99,90.73 106.99,83.93 103.05,79.99 87.82,79.99 79.57,88.24 73.86,88.24 71.15,85.53 60.63,85.53 60.04,86.12 55.52,86.12 54.85,86.79 42.18,86.79 42.06,86.9 40.54,86.9 39.32,85.68 39.32,83.93 39.7,83.55 39.7,81.03 37.26,78.6 37.26,75.07 32.27,70.08 32.27,69.01 27.37,64.11 27.37,63.52 26.24,62.39 25.39,62.39 25.16,62.17 25.16,61.64 25.35,61.45 v2(25.5,61.45)
  BOTTOM w0.076: UC1.AD6 129.72,101.07 v2(129.99,100.62)
  BOTTOM w0.104: v2(25.5,61.45) 25.37,61.58 25.37,62.08 24.46,62.99 23.8,62.99 23.54,62.72 LI3.1
USB20_N2_R: length 14.8
  BOTTOM w0.104: LI3.2 23.54,60.42 23.8,60.16 23.8,59.37 23.68,59.26 23.4,59.26 22.31,60.35 21.72,60.35 20.92,61.15 20.92,61.37 21.05,61.5 DI2.3 21.14,62.37 21.14,62.69 20.45,63.38 v4(19.86,63.38) 19.07,63.38 18.24,62.55 16.04,62.55 15.84,62.75 JUSB2.2
USB20_N4: length 192.6
  TOP w0.104: RI48.1 234.17,106.37 LI8.1 234.7,106.37 235.15,106.82 235.46,106.82 235.72,106.57 v2(235.72,106.49)
  IN3 w0.135: v2(128.11,100.61) 127.91,100.8 127.91,100.92 128.07,101.08 130.3,101.08 130.78,100.6 131.34,100.6 132.45,99.49 133.93,99.49 134.52,100.08 135.55,100.08 135.87,100.4 139.94,100.4 140.23,100.12 141.01,100.12 141.68,100.79 141.68,100.9 143.6,102.82 144.35,102.82 144.88,102.29 151.54,102.29 154.13,99.7 154.13,92.37 156.1,90.4 159.49,90.4 161.16,88.72 161.85,88.72 162.37,88.2 162.37,85.77 162.83,85.32 163.94,85.32 164.01,85.29 164.12,85.21 165.01,84.18 165.49,83.03 165.49,81.45 168.85,77.4 168.85,74.49 169.6,73.73 170.49,73.73 170.93,73.29 170.93,71.56 169.89,70.52 169.89,69.05 170.28,68.65 171.12,68.65 171.57,69.11 177.41,69.11 178.41,68.45 arc(186.57,64.62) 195.49,63.3 202.26,63.3 203.12,62.44 214.19,62.44 214.78,61.85 216.81,61.85 217.15,62.19 224.9,62.19 228.86,66.14 232.34,66.14 235.13,68.93 235.51,68.93 237.16,70.57 237.16,70.87 237.59,71.3 238.3,71.3 239.12,72.12 239.12,75.8 237.78,77.15 236.07,77.15 233.59,79.63 233.59,95.8 236.71,98.92 236.71,100.3 237.39,100.98 237.39,105.17 236.57,105.98 235.13,105.98 234.77,106.34 234.77,106.77 234.88,106.88 235.36,106.88 235.72,106.52 v2(235.72,106.49)
  BOTTOM w0.089: UC1.AD9 128.11,100.69 v2(128.11,100.61)
USB20_N4_L: length 6.7
  TOP w0.104: RI48.2 233.24,106.37 LI8.2 232.63,106.37 232.28,106.72 232.03,106.72 231.79,106.96 v4(231.79,107.8) 231.79,108.69 232.05,108.95 232.05,109.54 232.08,109.57 232.08,109.82 231.97,109.92 231.83,109.92 v2(231.61,109.71)
  BOTTOM w0.104: v2(231.61,109.71) 231.39,109.92 231.18,109.92 231.01,109.75 JNGFF2.9
USB20_N5: length 186.4
  TOP w0.104: LZ1.1 55.81,121.28 55.69,121.15 54.89,121.15 54.47,120.74 54.47,119.75 52.41,117.69 48.97,117.69 42,110.72 42,106.27 43.59,104.68 43.59,99.13 42.06,97.6 42.06,89.62 42.19,89.5 42.19,86.14 41.22,85.18 v2(41.22,84.3)
  IN1 w0.119: v2(41.22,84.3) 41.28,84.23 41.28,83.65 42.09,82.84 42.09,81.98 43.45,80.62 45.07,80.62 45.87,79.82 53.58,79.82 53.83,79.56 81.16,79.56 86.92,73.8 142.78,73.8 145.13,76.15 145.13,83.26 141,87.39 140.77,87.39 138.21,89.95 138.21,94.17 136.48,95.9 135.02,95.9 134.69,96.23 v2(134.69,96.77)
  BOTTOM w0.076: UC1.AJ1 132.33,97.78 132.33,97.68 132.46,97.55 134.21,97.55 134.39,97.37 134.39,97.08 v2(134.69,96.77)
USB20_N5_R: length 16.4
  TOP w0.104: LZ1.2 57.59,121.28 57.81,121.05 58.13,121.05 DV8.1 58.71,121.05 59.16,121.05 59.42,121.32 59.42,128.85 59.4,128.88 59.4,129.46 59.42,129.49 59.42,130.1 58.38,131.15 58.21,131.15 57.98,130.92 57.83,130.92 57.73,130.82 57.73,130.67 v2(57.81,130.59)
  BOTTOM w0.104: v2(57.81,130.59) 57.5,130.9 57.36,130.9 56.9,131.36 56.9,131.97 56.75,132.12 JEDP1.12
USB20_N7: length 146.5
  IN1 w0.119: v2(222.53,59.86) 222.37,60.02 222.37,60.48 222.04,60.81 220.04,60.81 218.99,59.76 215.45,59.76 214.7,60.52 178.76,60.52 177.8,61.48 174.03,61.48 170.39,65.13 163.56,65.13 163.24,65.45 150.74,65.45 146.42,69.76 146.42,85.81 146.22,86.01 146.22,86.94 145.26,87.9 145.26,92.88 143.43,94.71 139.75,94.71 137.97,96.48 137.97,97.07 136.2,98.84 135.63,98.84 135.38,99.1 133.5,99.1 133.21,98.8 133.21,98.61 v2(133.02,98.42)
  BOTTOM w0.076: UC1.AH1 131.96,98.53 131.92,98.49 131.81,98.49 131.75,98.55 131.75,98.7 131.8,98.76 131.81,98.76 131.88,98.76 132.01,98.81 132.13,98.81 132.13,98.81 132.34,98.75 132.7,98.75 132.95,98.85 133.38,98.85 133.51,98.72 133.51,98.53 133.4,98.42 v2(133.02,98.42)
  BOTTOM w0.104: v2(222.53,59.86) 222.18,60.21 222.08,60.21 221.98,60.32 221.98,61.17 222.37,61.56 222.37,71.93 227.51,77.06 227.51,78.49 227.67,78.65 227.9,78.65 228.31,78.24 LI9.1 228.92,78.24 RI50.1
USB20_N7_L: length 6.7
  BOTTOM w0.104: RI50.2 229.85,78.24 LI9.2 230.46,78.24 230.81,78.59 231.11,78.59 231.38,78.85 v4(231.38,79.07) 231.38,79.36 230.67,80.07 230.67,80.23 230.97,80.54 231.13,80.54 231.86,79.8 232.48,79.8 232.63,79.65 JNGFF1.5
USB20_N8: length 189.5
  TOP w0.104: v2(39.9,85.53) 39.44,85.98 39.44,86.52 40.79,87.87 40.79,88.94 40.69,89.04 40.69,95.66 40.66,95.69 40.66,96.26 40.69,96.29 40.69,98.13 42.21,99.65 42.21,103.84 39.89,106.16 39.89,108.15 40.66,108.92 40.66,111.31 48.41,119.07 v4(49.66,119.07) 50.81,119.07 50.84,119.1 51.42,119.1 51.44,119.07 51.68,119.07 52.2,119.58 52.2,119.87 52,120.07 LV27.3
  IN1 w0.119: v2(39.9,85.53) 40.38,85.05 41.27,85.05 42.34,86.12 52.74,86.12 55.8,83.06 58.66,83.06 61.41,80.31 81.41,80.31 87.23,74.49 142.55,74.49 144.48,76.42 144.48,83 140.77,86.7 140.54,86.7 137.51,89.73 137.51,93.75 136.1,95.16 133.48,95.16 132.03,96.61 130.29,96.61 129.33,97.57 128.11,97.57 127.66,98.02 127.66,98.63 127.91,98.88 127.91,99.43 v2(128.05,99.57)
  BOTTOM w0.089: UC1.AF8 128.05,99.66 v2(128.05,99.57)
USB20_N8_R: length 13.7
  TOP w0.104: LV27.4 52,121.76 52.19,121.95 52.19,122.23 53.09,123.13 53.09,123.36 52.97,123.48 52.41,123.48 DV4.2 52.44,123.91 52.98,123.91 53.09,124.02 53.09,124.27 52.02,125.33 v4(52.02,127.61) 52.02,129.24 51.99,129.26 51.99,129.84 52.02,129.87 52.02,130.97 v2(51.72,131.27)
  BOTTOM w0.104: JEDP1.2 51.75,131.93 51.91,131.77 51.91,131.46 v2(51.72,131.27)
USB20_N10: length 144.6
  IN1 w0.119: v2(129.25,99.53) 128.88,99.16 128.88,98.32 129.12,98.07 129.66,98.07 129.78,98.2 131.66,98.2 132.09,97.77 134.15,97.77 134.38,98 136.09,98 137.31,96.78 137.31,96.23 138.93,94.6 138.93,90.17 140.98,88.12 142.97,88.12 145.77,85.32 145.77,69.5 150.49,64.78 162.89,64.78 163.2,64.47 170.09,64.47 173.89,60.67 177.32,60.67 178.18,59.8 180.39,59.8 180.85,59.35 181.98,59.35 182.38,59.74 195.59,59.74 196.5,58.83 201.71,58.83 202.44,59.55 206.87,59.55 208.03,58.39 214.76,58.39 215.47,59.09 223.52,59.09 224.15,59.73 228.14,59.73 229.18,58.69 229.18,57.46 230.32,56.32 231.11,56.32 231.33,56.54 232.41,56.54 232.59,56.72 v2(232.59,56.93)
  BOTTOM w0.076: v2(129.25,99.53) 129.04,99.31 UC1.AH7
  BOTTOM w0.104: JUSH1.8 229.95,58.46 229.84,58.35 229.74,58.35 229.65,58.26 229.65,56.82 230.11,56.36 231.11,56.36 231.27,56.52 232.39,56.52 232.59,56.72 v2(232.59,56.93)
USB20_P1: length 207.7
  TOP w0.104: UI3.3 276.51,77.69 276.66,77.84 276.66,77.96 v2(276.46,78.16)
  IN3 w0.135: v2(127.4,101.73) 127.46,101.67 127.46,101.48 127.27,101.3 126.47,101.3 126.11,100.94 126.11,100.38 126.52,99.97 130.14,99.97 130.71,99.4 131.76,99.4 132.3,98.87 134.69,98.87 134.77,98.94 140.8,98.94 142.04,100.18 142.97,100.18 143.55,100.76 144.33,100.76 144.7,101.12 145.89,101.12 146.54,100.47 149.31,100.47 150.6,99.18 150.6,93.42 153.02,91 153.02,88.76 151.2,86.95 151.2,84.98 149.23,83 149.23,72.82 151.87,70.18 160.04,70.18 163.68,66.54 178.49,66.54 179.54,65.93 arc(186.96,62.88) 194.91,61.84 201.49,61.84 202.35,60.99 213.37,60.99 214,60.35 217.38,60.35 217.69,60.67 226.64,60.67 228.93,58.38 233.44,58.38 235.96,55.86 240.68,55.86 245.74,60.92 245.74,61.77 249.22,65.24 249.22,66.9 249.86,67.54 249.86,68.87 253.12,72.13 255.99,72.13 259.05,75.19 260.96,75.19 262.24,76.47 262.24,77.85 263.08,78.69 263.9,78.69 265.27,80.06 267.4,80.06 268.68,78.77 276.6,78.77 276.72,78.65 276.72,78.41 276.47,78.16 v2(276.46,78.16)
  BOTTOM w0.089: UC1.AB10 127.08,102.04 v2(127.4,101.73)
USB20_P1_R: length 11.7
  BOTTOM w0.104: LI7.3 278.92,74.86 279.17,74.61 279.33,74.61 279.44,74.72 279.44,75.37 279.79,75.73 279.79,76.35 279.39,76.76 DI5.3 278.84,76.95 279.56,77.67 279.89,77.67 280.58,78.37 280.58,79.37 281.11,79.89 v4(281.57,79.89) 282.38,79.89 282.92,79.36 283.82,79.36 JUSB1.3
USB20_P2: length 147.2
  IN1 w0.119: v2(129.28,100.61) 129.44,100.61 129.56,100.49 129.56,100.3 129.44,100.18 125.16,100.18 125.04,100.29 119.1,100.29 118.6,99.8 118.6,98.96 116.89,97.24 116.89,93.4 115.37,91.88 107.83,91.88 106.77,90.82 106.77,84.02 102.96,80.21 87.91,80.21 79.66,88.46 73.77,88.46 71.06,85.75 60.72,85.75 60.14,86.34 55.61,86.34 54.94,87.01 42.27,87.01 42.15,87.12 40.45,87.12 39.1,85.78 39.1,83.84 39.48,83.46 39.48,81.12 37.04,78.69 37.04,75.16 32.05,70.17 32.05,69.1 27.15,64.2 27.15,63.61 26.15,62.61 25.3,62.61 24.94,62.26 24.94,61.65 v2(24.74,61.44)
  BOTTOM w0.076: v2(129.28,100.61) 129.28,100.82 UC1.AD7
  BOTTOM w0.104: v2(24.74,61.44) 24.79,61.39 24.98,61.39 25.08,61.49 25.08,61.68 25.17,61.77 25.17,61.99 24.38,62.79 23.89,62.79 23.74,62.64 23.74,62.47 23.84,62.37 24.05,62.37 24.14,62.28 LI3.4
USB20_P2_R: length 14.8
  BOTTOM w0.104: LI3.3 24.14,60.33 24.03,60.22 v4(24.03,59.7) 24.03,59.32 23.77,59.06 23.32,59.06 22.23,60.15 21.63,60.15 20.71,61.07 20.71,61.2 20.41,61.5 DI2.2 20.94,62.37 20.94,62.6 20.36,63.18 20.19,63.18 20.16,63.15 19.56,63.15 19.53,63.18 19.15,63.18 18.32,62.35 15.82,62.35 15.61,62.14 15.61,61.68 JUSB2.3
USB20_P4: length 192.6
  TOP w0.104: RI47.1 234.17,107.27 LI8.4 234.84,107.27 235.09,107.02 235.59,107.02 v2(235.71,107.15)
  IN3 w0.135: v2(127.4,100.61) 127.67,100.88 127.67,101.02 127.97,101.32 130.4,101.32 130.88,100.84 131.44,100.84 132.55,99.73 133.83,99.73 134.42,100.32 135.45,100.32 135.77,100.64 140.04,100.64 140.33,100.36 140.91,100.36 141.44,100.89 141.44,101 143.5,103.06 144.45,103.06 144.98,102.53 151.64,102.53 154.37,99.8 154.37,92.47 156.2,90.64 159.59,90.64 161.26,88.96 161.95,88.96 162.61,88.3 162.61,85.87 162.93,85.56 163.98,85.56 164.13,85.5 164.29,85.38 165.22,84.31 165.73,83.08 165.73,81.53 169.09,77.48 169.09,74.59 169.7,73.98 170.59,73.98 171.17,73.39 171.17,71.46 170.13,70.42 170.13,69.15 170.38,68.9 171.02,68.9 171.47,69.35 177.49,69.35 178.55,68.65 arc(186.64,64.85) 195.49,63.54 202.36,63.54 203.22,62.68 214.29,62.68 214.88,62.1 216.71,62.1 217.05,62.43 224.8,62.43 228.76,66.38 232.24,66.38 235.03,69.17 235.41,69.17 236.92,70.67 236.92,70.97 237.49,71.54 238.2,71.54 238.88,72.22 238.88,75.7 237.68,76.91 235.97,76.91 233.35,79.53 233.35,95.9 236.47,99.02 236.47,100.4 237.15,101.08 237.15,105.07 236.47,105.74 235.03,105.74 234.53,106.24 234.53,106.87 234.81,107.15 v2(235.71,107.15)
  BOTTOM w0.089: v2(127.4,100.61) 127.4,100.75 UC1.AD10
USB20_P4_L: length 6.7
  TOP w0.104: RI47.2 233.24,107.27 LI8.3 232.63,107.27 232.28,106.92 232.11,106.92 231.99,107.04 231.99,107.48 232.02,107.51 232.02,108.08 231.99,108.11 231.99,108.61 232.28,108.9 v4(232.28,109.26) 232.28,109.9 232.06,110.12 231.83,110.12 v2(231.61,110.34)
  BOTTOM w0.104: v2(231.61,110.34) 231.39,110.12 231.18,110.12 231.05,110.25 JNGFF2.7
USB20_P5: length 186.4
  TOP w0.104: v2(41.88,84.59) 41.88,84.58 41.77,84.47 41.63,84.47 41.42,84.67 41.42,85.09 42.39,86.06 42.39,89.58 42.26,89.7 42.26,97.52 43.79,99.04 43.79,104.76 42.2,106.35 42.2,110.64 49.05,117.49 52.49,117.49 54.67,119.67 54.67,120.66 54.97,120.95 55.68,120.95 55.95,120.68 LZ1.4
  IN1 w0.119: v2(41.88,84.59) 41.64,84.35 41.64,84.12 41.5,83.99 41.5,83.74 42.3,82.93 42.3,82.07 43.54,80.83 45.16,80.83 45.96,80.04 53.67,80.04 53.92,79.78 81.25,79.78 87.01,74.02 142.69,74.02 144.91,76.24 144.91,83.17 140.91,87.17 140.67,87.17 137.99,89.86 137.99,94.08 136.39,95.68 134.93,95.68 134.42,96.19 134.42,96.42 134.06,96.78 v2(134.06,96.78)
  BOTTOM w0.076: v2(134.06,96.78) 134.06,96.79 134.21,96.94 134.21,97.3 134.14,97.38 132.38,97.38 131.89,97.87 UC1.AJ2
USB20_P5_R: length 16.1
  TOP w0.104: LZ1.3 57.59,120.68 57.76,120.85 58.2,120.85 DV7.1 58.64,120.85 59.25,120.85 59.63,121.23 v4(59.63,129.17) 59.63,130.19 58.46,131.35 v2(57.81,131.35)
  BOTTOM w0.104: JEDP1.13 57.25,132.12 57.1,131.97 57.1,131.44 57.44,131.1 57.56,131.1 v2(57.81,131.35)
USB20_P7: length 146.5
  IN1 w0.119: v2(221.78,59.86) 221.97,59.86 222.15,60.04 222.15,60.39 221.95,60.59 220.13,60.59 219.08,59.55 215.36,59.55 214.61,60.3 178.67,60.3 177.71,61.26 173.94,61.26 170.3,64.91 163.47,64.91 163.15,65.23 150.65,65.23 146.2,69.67 146.2,85.71 146,85.91 146,86.85 145.04,87.81 145.04,92.78 143.34,94.49 139.66,94.49 137.76,96.39 137.76,96.98 136.11,98.63 135.54,98.63 135.29,98.88 133.6,98.88 133.42,98.71 133.42,98.39 133.55,98.26 v2(133.86,98.26)
  BOTTOM w0.076: UC1.AH2 131.58,98.68 131.58,98.77 131.68,98.87 131.71,98.9 131.78,98.93 131.85,98.93 132.01,98.98 132.15,98.98 132.18,98.97 132.37,98.92 132.67,98.92 132.92,99.02 133.45,99.02 133.68,98.79 133.68,98.44 v2(133.86,98.26)
  BOTTOM w0.104: v2(221.78,59.86) 221.78,61.25 222.17,61.64 222.17,72.01 227.3,77.15 227.3,78.57 227.58,78.85 228.03,78.85 228.31,79.14 LI9.4 228.92,79.14 RI49.1
USB20_P7_L: length 6.7
  BOTTOM w0.104: JNGFF1.3 232.64,80.15 232.49,80 231.95,80 231.19,80.76 230.87,80.76 v4(230.67,80.56) 230.44,80.33 230.44,80.02 231.1,79.36 231.1,78.89 231,78.79 230.81,78.79 230.46,79.14 LI9.3 229.85,79.14 RI49.2
USB20_P8: length 189.5
  TOP w0.104: LV27.2 52.6,120.06 52.4,119.86 52.4,119.5 51.77,118.87 v4(51.13,118.87) 49.97,118.87 49.94,118.84 49.37,118.84 49.34,118.87 48.5,118.87 40.86,111.23 40.86,108.84 40.09,108.07 40.09,107.39 40.12,107.36 40.12,106.79 40.09,106.76 40.09,106.25 42.41,103.92 42.41,99.57 40.89,98.05 40.89,89.13 40.99,89.03 40.99,87.79 39.64,86.44 39.64,86.07 39.74,85.97 v2(40.36,85.97)
  IN1 w0.119: v2(127.26,99.57) 127.53,99.57 127.69,99.41 127.69,98.97 127.44,98.72 127.44,97.93 128.02,97.35 129.24,97.35 130.2,96.39 131.94,96.39 133.39,94.94 136.01,94.94 137.29,93.66 137.29,89.64 140.45,86.48 140.68,86.48 144.26,82.91 144.26,76.51 142.46,74.71 87.32,74.71 81.5,80.53 61.5,80.53 58.75,83.27 55.89,83.27 52.83,86.34 42.25,86.34 41.18,85.26 40.47,85.26 40.37,85.37 40.37,85.96 v2(40.36,85.97)
  BOTTOM w0.089: v2(127.26,99.57) 127.26,99.66 127.61,100 UC1.AF9
USB20_P8_R: length 13.5
  TOP w0.104: v2(52.3,131.27) 52.22,131.19 v4(52.22,129.55) 52.22,127.92 52.25,127.89 52.25,127.32 52.22,127.29 52.22,125.42 53.29,124.35 53.29,124.02 53.39,123.91 53.91,123.91 DV4.3 53.94,123.48 53.43,123.48 53.29,123.34 53.29,123.05 52.39,122.15 52.39,121.94 52.6,121.73 LV27.1
  BOTTOM w0.104: v2(52.3,131.27) 52.11,131.46 52.11,131.79 52.25,131.93 JEDP1.3
USB20_P10: length 144.6
  IN1 w0.119: v2(232.6,56.17) 232.46,56.32 231.42,56.32 231.2,56.1 230.23,56.1 228.96,57.37 228.96,58.6 228.05,59.51 224.24,59.51 223.61,58.88 215.56,58.88 214.85,58.17 207.94,58.17 206.78,59.33 202.53,59.33 201.8,58.61 196.41,58.61 195.5,59.52 182.47,59.52 182.07,59.13 180.76,59.13 180.3,59.58 178.09,59.58 177.22,60.45 173.8,60.45 170,64.26 163.11,64.26 162.8,64.56 150.4,64.56 145.55,69.41 145.55,85.22 142.88,87.9 140.89,87.9 138.72,90.08 138.72,94.51 137.09,96.14 137.09,96.69 135.99,97.78 134.48,97.78 134.24,97.55 132,97.55 131.57,97.98 129.87,97.98 129.75,97.86 129.03,97.86 128.66,98.23 v2(128.66,99.54)
  BOTTOM w0.076: UC1.AH8 128.39,99.26 v2(128.66,99.54)
  BOTTOM w0.104: JUSH1.9 229.45,56.74 230.03,56.16 231.19,56.16 231.35,56.32 232.46,56.32 v2(232.6,56.17)
USB_OC0#: length 254.4
  TOP w0.112: v2(279.11,75.64) 279.11,75.26 278.86,75.02 UI3.13
  IN2 w0.124: v2(152.35,93.18) 151.99,93.54 151.99,98.97 149.76,101.2 149.76,104.56 149.3,105.01 149.3,105.69 149.55,105.94 149.55,107.56 151.36,109.36 151.36,110.47 150.52,111.31 v2(150.52,119.75) ; v2(270.2,76.13) 270.2,69.64 268.77,68.21 261.47,68.21 261.07,67.81 261.07,67.26 259.79,65.97 256.18,65.97 255.88,65.67 252.8,65.67 251.79,64.65 249.5,64.65 245.08,60.23 245.08,59.37 242.91,57.2 237.19,57.2 234.54,54.55 233.83,54.55 233.54,54.26 226.19,54.26 225.98,54.47 213.95,54.47 213.59,54.11 204.37,54.11 200.13,58.35 196.15,58.35 195.47,59.03 183.21,59.03 182.89,58.71 182.42,58.71 181.66,57.95 180.36,57.95 179.17,59.14 176.12,59.14 175.44,58.46 171.84,58.46 169.25,61.04 165.89,61.04 165.37,60.52 160.72,60.52 160.27,60.97 160.27,62.44 157.95,64.77 149.41,64.77 148.44,65.75 147.55,65.75 142.87,70.42 142.87,71.66 138.84,75.7 138.84,79.82 v2(140.36,81.34)
  IN3 w0.135: v2(140.36,81.34) 140.36,81.98 140.94,82.55 140.94,83.39 141.65,84.11 143.53,84.11 144.57,85.15 144.57,88.22 148.59,92.24 v2(148.59,93.18) ; v2(131.42,119.32) 131.72,119.32 133.93,121.53 148.74,121.53 v2(150.52,119.75) ; v2(270.2,76.13) 270.78,76.13 271.85,75.07 275.49,75.07 276.06,74.5 277.96,74.5 v2(279.11,75.64)
  BOTTOM w0.102: UC1.A9 127.76,113.63 129.46,115.33
  BOTTOM w0.112: v2(152.35,93.18) v1(150.06,93.18) v2(148.59,93.18) ; RPC3.3 131.98,119.67 131.62,119.32 v2(131.42,119.32) 131.06,119.32 130.78,119.04 130.78,117.41 129.46,116.09 129.46,115.33
USB_OC1#: length 216
  IN1 w0.119: v2(130.64,122.63) 129.82,123.46 125.26,123.46 116.93,131.78 108.72,131.78 107.04,133.46 83.23,133.46 79.16,129.39 76.69,129.39 73.61,132.47 49.53,132.47 45.46,128.4 36.62,128.4 35.28,127.06 30.99,127.06 27.16,123.23 27.16,113.44 26.58,112.86 25.69,112.86 25.49,112.66 25.49,110.31 25.87,109.93 25.87,108.41 25.3,107.83 25.3,101.74 23.52,99.96 19.33,99.96 19.31,99.98 15.98,99.98 15.58,99.58 14.69,99.58 14.18,100.09 12.98,100.09 12.39,99.5 12.39,99.18 12.39,99.18 12.39,95.94 12.39,95.93 12.39,95.85 13.11,95.13 13.11,91.58 13.87,90.81 13.87,82.3 13.91,82.27 13.91,82.25 13.92,82.24 13.92,82.23 15.67,80.48 15.67,76.8 19.36,73.11 19.36,62.75 23.06,59.05 v2(23.06,58.66)
  BOTTOM w0.102: 129.66,115.2 128.09,113.63 128.09,112.55 127.76,112.22 UC1.C9
  BOTTOM w0.112: UI1.3 22.69,55.52 23.34,56.17 23.34,58.38 v2(23.06,58.66) ; v2(130.64,122.63) 130.64,121.18 130.91,120.91 132.31,120.91 132.48,120.74 RPC3.2 132.48,119.85 131.46,118.83 v1(131.22,118.83) 131.19,118.83 131.01,118.65 131.01,117.35 129.66,116 129.66,115.2
USB_OC2#: length 11.6
  BOTTOM w0.112: RPC3.1 132.98,120.07 131.29,118.38 131.29,117.1 v1(131.11,116.92) 129.97,115.78 129.97,115.14 128.32,113.49 128.32,112.77 128.63,112.46 128.63,112.22 128.43,112.02 128.24,112.02 127.76,111.55 UC1.D9
USB_OC3#: length 9.5
  BOTTOM w0.102: 129.26,115.43 127.45,113.62 127.45,112.98 UC1.B9
  BOTTOM w0.112: 129.26,115.43 129.26,116.31 v1(129.51,116.55) 130.55,117.6 130.55,119.16 131.48,120.09 RPC3.4
USB_PWR_EN1#: length 274.9
  TOP w0.107: v2(254.18,79.07) 253.64,78.53 253.64,78.24 253.71,78.18 RPE11.3 ; UE1.K3 v2(254.28,85.06)
  IN1 w0.119: v2(254.18,79.07) 253.43,79.81 253.43,83.46 253.77,83.81 253.77,84.53 254.28,85.04 v2(254.28,85.06)
  IN2 w0.124: v2(64.98,57.15) 65.42,57.59 69.28,57.59 69.73,57.14 71.63,57.14 75.65,53.11 102.9,53.11 104.02,54.23 140.26,54.23 141.79,55.38 144.7,55.38 146.2,56.88 159.23,56.88 161.44,54.67 177.61,54.67 179.71,52.57 183.33,52.57 184.66,51.24 208.64,51.24 210.15,52.75 213.74,52.75 214.24,52.24 218.53,52.24 219.63,53.34 225.51,53.34 226.02,52.83 229.54,52.83 229.9,52.47 234.36,52.47 237.46,55.57 v2(237.46,56.55)
  IN3 w0.135: v2(254.18,79.07) 254.14,79.07 253.26,78.19 253.26,77.18 252.6,76.52 249.91,76.52 248.97,75.58 248.97,71.84 247.7,70.57 247.7,69.91 247.27,69.48 247.27,66.71 245.41,64.86 245.41,63.07 244.59,62.24 244.59,61.4 241.18,57.99 238.29,57.99 237.46,57.17 v2(237.46,56.55)
  BOTTOM w0.112: UI1.4 25.16,53.12 v1(25.35,53.31) 39.05,53.31 39.65,52.71 39.65,51.19 41.12,49.72 61.81,49.72 62.56,50.47 62.56,52.39 64.82,54.65 64.82,56.99 v2(64.98,57.15)
USB_PWR_EN2#: length 10.8
  TOP w0.112: v2(251.08,86.66) UE1.G5 ; v2(252.68,78.26) 253.02,78.26 253.21,78.07 RPE11.4
  IN1 w0.119: v2(251.08,86.66) 251.1,86.66 251.47,86.28 251.47,85.72 252.61,84.58 252.61,79.69 252.37,79.45 252.37,78.56 v2(252.68,78.26)
USB_PWR_SHR_LFT_EN#: length 31
  TOP w0.107: RPE11.2 254.21,78.31 v2(254.09,78.43) ; UE1.J3 v2(253.48,85.06)
  TOP w0.112: UI3.6 v2(274.41,76.02)
  IN1 w0.119: v2(274.41,76.02) 274.03,76.4 272.39,76.4 271.21,77.58 264.46,77.58 263.55,78.5 262.79,78.5 262.66,78.37 255.36,78.37 254.98,77.99 254.53,77.99 v2(254.09,78.43) 254.09,78.48 253.79,78.78 253.79,79.08 253.21,79.66 253.21,83.62 253.48,83.9 v2(253.48,85.06)
USB_PWR_SHR_VBUS_EN: length 29.7
  TOP w0.107: RPE11.1 v2(254.71,78.43) 255.33,79.06 255.33,81.27 v1(254.2,82.41) 253.52,83.08 253.52,84.22 UE1.J2
  TOP w0.112: UI3.5 274.55,76.52 v2(274.41,76.66)
  IN1 w0.119: v2(274.41,76.66) 272.52,76.66 271.36,77.81 264.62,77.81 263.68,78.75 262.66,78.75 262.53,78.62 254.9,78.62 v2(254.71,78.43)
USBCOMP: length 2
  TOP w0.112: v1(129.21,102.22) 129.35,102.08 v2(129.35,101.72) 129.41,101.66 129.92,101.66 RC44.1
  BOTTOM w0.102: v2(129.35,101.72) 129.69,102.05 UC1.AB6
USH_DET#: length 66.7
  TOP w0.112: RZ87.1 221.06,58.57 DZ7.2 ; RE526.2 219.92,55.69 219.92,58.31 DZ7.2 ; UE1.C13 248.28,94.12 248.21,94.19 v2(248.18,94.19) ; DZ7.2 220.28,59 220.06,59.22 220.06,59.97 220.4,60.31 226.8,60.31 v1(227.41,59.71) 227.97,59.15 229.39,59.15 230.03,59.79 v2(230.03,60.06)
  IN3 w0.135: v2(230.03,60.06) 230.03,60.63 231.04,61.63 236.36,61.63 237.53,62.8 240.79,62.8 243.53,65.54 243.53,68.48 245.34,70.29 245.34,73.42 244.37,74.38 244.37,81.34 243.94,81.77 243.94,82.81 244.42,83.3 244.42,84.44 245.42,85.43 245.42,91.43 v2(248.18,94.19)
USH_DET#_R: length 4.9
  TOP w0.112: v1(220.33,56.22) 220.8,56.69 v2(220.8,56.83) 220.62,57.01 DZ7.1 221.59,57.6 RZ87.2
  BOTTOM w0.112: v2(220.8,56.83) 220.95,56.98 JUSH1.26
USH_PWR_STATE#: length 86.9
  TOP w0.112: UE2.9 v2(271.23,93.22) v3(271.72,93.72) ; v2(222.72,56.84) 222.72,56.84 222.72,56.85 222.53,57.04 RZ10.2
  IN2 w0.124: v2(222.72,56.84) 222.72,56.84 222.72,56.73 224.53,54.93 226.16,54.93 226.38,54.71 233.35,54.71 233.64,55 234.36,55 237,57.65 242.72,57.65 244.6,59.53 244.6,60.41 249.3,65.11 251.53,65.11 252.55,66.13 255.68,66.13 255.98,66.43 258.9,66.43 260.56,68.1 261,68.1 261.34,68.44 268.68,68.44 269.83,69.59 269.83,75.64 269.26,76.21 269.26,77.68 267.04,79.91 267.04,83.27 266.01,84.3 266.01,87.4 271.23,92.62 v2(271.23,93.22)
  BOTTOM w0.107: JUSH1.22 222.95,57.15
  BOTTOM w0.112: 222.95,57.15 222.72,56.92 v2(222.72,56.84)
USH_RST#_R: length 4.8
  TOP w0.112: RZ114.2 223.33,57.2 v2(223.33,56.87) 223.33,56.69 223.09,56.45 222.15,56.45 v1(222.02,56.58)
  BOTTOM w0.107: v2(223.33,56.87) 223.45,56.99 JUSH1.21
USH_SMBCLK: length 60.8
  TOP w0.112: UE1.B3 v2(247.08,85.06) ; v2(234.29,54.1) 234.13,53.94 233.71,53.94 233.36,54.29 RZ8.2 CZ62.1 232.12,53.98 231.71,53.98 231.2,54.49 230.03,54.49 229.54,54 229.54,53.04 229.33,52.83 v4(228.84,52.83) 228.54,52.83 228.33,53.04 228.33,55.14 v2(228.51,55.33)
  BOTTOM w0.112: v2(234.29,54.1) 234.71,53.68 234.71,52.7 235.28,52.13 239.01,52.13 239.93,53.05 239.93,53.75 245.04,58.85 245.04,60.32 246.5,61.77 246.5,63.32 248.02,64.85 248.02,68.12 250.28,70.38 250.28,74.21 251.02,74.95 251.02,80.05 250.21,80.85 250.21,82.98 249.99,83.21 249.34,83.21 247.95,84.59 247.55,84.59 v2(247.08,85.06) ; v2(228.51,55.33) 228.34,55.5 228.34,58.33 228.45,58.43 JUSH1.11
USH_SMBDAT: length 62.1
  TOP w0.107: v2(249.48,86.66) UE1.E5
  TOP w0.112: v2(234.29,53.51) 234.1,53.7 233.6,53.7 RZ9.2 CZ63.1 232.12,53.74 231.61,53.74 231.1,54.25 230.13,54.25 229.78,53.9 229.78,52.94 229.43,52.59 228.44,52.59 228.09,52.94 228.09,55.17 v2(227.93,55.33)
  BOTTOM w0.112: v2(234.29,53.51) 234.47,53.34 234.47,52.61 235.18,51.89 239.11,51.89 240.17,52.95 240.17,53.65 245.28,58.75 245.28,60.22 246.73,61.67 246.73,63.22 248.26,64.75 248.26,68.02 250.52,70.28 250.52,74.11 251.26,74.85 251.26,80.15 250.45,80.95 250.45,83.08 250.09,83.45 249.43,83.45 249.08,83.8 249.08,86.26 v2(249.48,86.66) ; JUSH1.12 227.95,58.5 228.1,58.34 228.1,55.5 v2(227.93,55.33)
VCI_IN1#: length 13.1
  TOP w0.112: v2(244.25,86.02) 244.69,85.58 245.54,85.58 246.58,86.62 247.05,86.62 UE1.B5 ; v1(237.81,82.42) v2(238.17,82.79) 237.97,82.99 RE507.1
  IN2 w0.124: v2(238.17,82.79) 238.17,83.34 240.51,85.68 243.56,85.68 243.9,86.02 v2(244.25,86.02)
VCI_IN2#: length 16
  TOP w0.112: UE1.D4 v2(248.68,85.86) ; v1(237.04,85.8) 237.6,85.8 RE508.1 237.97,86.52 238.39,86.94 v2(238.64,86.94)
  IN2 w0.124: v2(238.64,86.94) 238.31,87.27 238.31,87.67 239.29,88.64 240.56,88.64 241.77,87.43 242.37,87.43 242.98,86.83 245.52,86.83 246.89,85.46 248.28,85.46 v2(248.68,85.86)
VCT_LAN_R1: length 2.3
  TOP w0.112: UL1.6 246.08,122.44 246.02,122.39 v1(246.02,121.75) 246.02,121.68 245.58,121.23 RL3.1
VGA_ID: length 12.6
  TOP w0.107: UE1.H11 v2(252.66,92.23)
  TOP w0.112: v1(251.75,99.38) 251.67,99.45 v2(251.67,100.21) 250.99,100.21 RE85.1 250.54,101.59 RE84.1
  BOTTOM w0.112: v2(251.67,100.21) 252.68,99.2 252.68,92.26 v2(252.66,92.23)
VID0_PRIM_CORE: length 4.5
  TOP w0.112: PR408.2 156.98,130.17 156.17,129.36 v1(156.17,129.22)
  TOP w0.254: PR408.2 PR418.2 PR420.1 v2(158.77,129.55)
  BOTTOM w0.254: PU402.9 158.85,129.03 158.77,129.11 v2(158.77,129.55)
VID0_VCCIO: length 4.7
  TOP w0.112: PR414.2 v1(141.22,132.84)
  TOP w0.254: PR414.2 143.06,132.84 PR416.1 143.28,132.65 v2(143.28,132.15)
  BOTTOM w0.254: PU401.9 143.4,130.55 143.58,130.73 143.58,131.29 143.28,131.58 v2(143.28,132.15)
VID1_PRIM_CORE: length 4.5
  BOTTOM w0.112: v1(159.92,133.44) 159.5,133.44 PR417.2
  BOTTOM w0.254: PR417.2 159.03,132.1 PR411.2 PR419.1 159.02,130.94 158.25,130.17 PU402.8
VID1_VCCIO: length 3.7
  BOTTOM w0.112: PR413.2 143.08,134.63 v1(143.15,134.71)
  BOTTOM w0.254: PU401.8 142.38,131.7 142.77,132.09 142.77,132.55 PR415.1 PR413.2
VIDALERT_N: length 78.7
  TOP w0.112: v2(43.46,94.47) PR625.1
  IN1 w0.119: v2(93.8,118.25) 92.69,119.36 87.54,119.36 86.8,118.61 79.68,118.61 79.17,119.12 77.72,119.12 77.21,118.61 71.33,118.61 70.87,119.07 70.84,119.07 70.21,119.7 66.27,119.7 65.86,120.12 52.8,120.12 50.72,118.04 48.69,118.04 44.12,113.47 44.12,107.68 43.66,107.23 43.66,103.31 44.11,102.87 44.11,97.1 43.04,96.04 43.04,94.86 43.43,94.47 v2(43.46,94.47)
  BOTTOM w0.112: PR604.2 43.61,94.63 v2(43.46,94.47) ; RC152.1 93.56,120.65 RC153.2 94.04,119.3 94.04,118.49 v2(93.8,118.25)
VIDALERT_N_B: length 2.3
  TOP w0.112: PR625.2 46.68,93.97 PU602.36
VIDSCLK: length 86
  TOP w0.112: v2(43.46,93.8) PR618.1
  IN1 w0.119: v2(94.97,118.24) 93.35,119.86 87.33,119.86 86.59,119.11 79.89,119.11 79.38,119.62 77.51,119.62 77,119.11 71.54,119.11 70.45,120.2 66.48,120.2 66.07,120.62 52.59,120.62 50.52,118.54 48.49,118.54 43.62,113.67 43.62,107.92 43.16,107.46 43.16,103.1 43.61,102.66 43.61,97.39 42.53,96.32 42.53,94.65 43.38,93.8 v2(43.46,93.8)
  BOTTOM w0.076: 95.93,116.19 v1(95.93,115.68) 95.93,115.2 96.61,114.52 96.61,113.38 UC1.A63
  BOTTOM w0.102: 95.93,116.19 95.41,116.71 CC321.1
  BOTTOM w0.112: v2(94.97,118.24) 94.97,118.44 CC321.1 ; PR601.2 44.02,93.8 v2(43.46,93.8)
VIDSCLK_B: length 2.4
  TOP w0.112: PR618.2 45.77,93.66 46.51,93.66 46.71,93.57 PU602.37
VIDSOUT: length 88.4
  TOP w0.112: v2(43.46,95.64) PR626.1
  IN1 w0.119: v2(92.67,118.25) 92.67,118.67 92.52,118.82 91.83,118.82 91.71,118.7 91.71,117.66 91.59,117.54 91.35,117.54 91.23,117.66 91.23,118.74 91.11,118.85 90.87,118.85 90.75,118.74 90.75,117.66 90.63,117.54 89.44,117.54 89.32,117.66 89.32,118.74 89.2,118.85 88.96,118.85 88.84,118.74 88.84,117.66 88.72,117.54 87.53,117.54 87.41,117.66 87.41,117.99 87.29,118.11 71.13,118.11 70.67,118.57 70.63,118.57 70.04,119.16 66.11,119.16 65.7,119.57 52.96,119.57 50.93,117.54 48.9,117.54 44.62,113.26 44.62,107.48 44.16,107.02 44.16,103.55 44.61,103.1 44.61,96.79 v2(43.46,95.64)
  BOTTOM w0.076: 94.18,117.26 94.18,117.21 95.4,115.99 95.4,115.12 96.24,114.29 96.24,113.6 96.2,113.56 96.2,112.67 96.41,112.46 96.41,112.22 96.11,111.93 UC1.D64
  BOTTOM w0.112: 94.18,117.26 93.85,117.59 93.12,117.59 92.67,118.03 v2(92.67,118.25) RC157.1 ; v3(42.82,95.32) 43.14,95.64 v2(43.46,95.64) 43.59,95.51 PR605.2
VIDSOUT_B: length 2.5
  TOP w0.112: PU602.35 46.95,94.37 46.62,94.42 PR626.2
VRALERT#: length 22.7
  TOP w0.112: v2(125.65,96.64) 125.65,96.11 126.1,95.65 126.78,95.65 v1(127.02,95.41) 127.11,95.32 127.72,95.32 128.22,94.83 128.69,94.83 128.99,95.13 129.49,95.13 129.75,94.87 129.75,94.18 137.03,86.9 138.6,86.9 139.52,85.99 140.99,85.99 141.57,85.41 RC73.1
  BOTTOM w0.102: v2(125.65,96.64) 126.06,97.05 UC1.AM11
VSA_SEN+: length 126.4
  TOP w0.112: v2(116.55,114.23) 116.55,114.23 116.85,114.23 116.93,114.31 116.93,116.23 117.19,116.49 117.19,120.13 RC168.2
  TOP w0.203: PC650.1 52.08,100.28 PC652.1 51.22,100.4 v2(51.89,101.08)
  IN3 w0.135: v2(116.55,114.23) 116.55,113.95 116.45,113.85 116.45,112.93 116.78,112.6 117.34,112.6 117.75,112.19 117.75,111.42 117.45,111.11 117.45,109.23 118.16,108.52 120.27,108.52 120.66,108.92 v2(121.09,108.91) ; v2(51.89,101.08) 52.08,101.26 52.08,101.64 50.63,103.09 50.63,107.15 49.7,108.08 47.92,108.08 46.76,109.25 46.76,115.4 49.62,118.26 51.79,118.26 52.93,119.41 65.7,119.41 66.17,118.93 68.15,118.93 68.99,118.09 69.35,118.09 69.51,118.25 69.51,118.38 v2(69.34,118.55)
  BOTTOM w0.102: PR649.2 v3(53.55,99.39)
  BOTTOM w0.112: v2(116.55,114.23) 116.35,114.04 115.97,114.04 115.37,114.64 114.58,114.64 108.46,120.76 106.93,120.76 103.77,123.92 95.1,123.92 94.87,123.7 88.94,123.7 87.76,122.52 86.96,122.52 86.76,122.71 86.76,124.21 83.66,127.32 76.37,127.32 75.22,126.17 75.22,125.23 75.67,124.78 75.67,124.03 72.39,120.74 70.48,120.74 69.53,119.79 69.53,118.75 v2(69.34,118.55)
  BOTTOM w0.203: PR649.2 PC640.2 52.55,100.37 51.97,100.95 51.97,101 v2(51.89,101.08)
  BOTTOM w0.254: UC1.H20 121.36,108.64 v2(121.09,108.91)
