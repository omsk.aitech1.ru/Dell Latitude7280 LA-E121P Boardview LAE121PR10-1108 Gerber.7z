# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LX_1.8VALW: length 1.3
  BOTTOM w0.112: v1(173.51,61.42) PR502.1
LX_1V_PRIM: length 2.2
  TOP w0.508: v2(155.18,129.36) 155.03,129.36 PR409.1
  BOTTOM w0.112: v2(155.18,129.36) 155.18,129.69 v1(154.68,130.19)
LX_1VS_VCCIO: length 2
  TOP w0.112: PR405.1 v1(138.52,132.54)
  TOP w0.508: v2(139.34,131.14) 138.96,131.52 PR405.1
LX_3V: length 1.7
  BOTTOM w0.112: PR106.1 v1(158.84,70.42)
  vias: v2(152.47,74.1) v2(152.98,73.85) v2(156.06,74) v2(156.67,74)
LX_5V:
  vias: v2(182.83,54.24) v2(183.41,54.24) v2(187.22,54.47) v2(187.22,53.86) v3(186.46,54.15)
LX_DDR: length 1.4
  TOP w0.112: PR202.1 v1(67.65,64.98)
  vias: v2(67.33,67.52) v2(67.97,67.52)
M2280_DEVSLP: length 223.2
  TOP w0.112: v2(134.49,108.98) 133.98,108.47 130.81,108.47 v2(130.32,108.96) ; v2(23.87,47.59) 23.87,46.98 RN37.2
  IN1 w0.076: JNGFF3.38 19.7,42.2
  IN1 w0.119: v2(145.44,60.31) 145.41,60.31 144.88,60.84 144.88,61.61 143.74,62.75 142.75,62.75 139.51,65.98 73.87,65.98 73.05,65.16 73.05,63.45 73.56,62.94 73.56,56.12 72.4,54.96 69.8,54.96 69.06,55.71 63.98,55.71 63.23,54.95 62.32,54.95 60.88,53.52 60.88,53.18 60.57,52.87 59.9,52.87 59.25,52.22 52.38,52.22 52.16,52.44 48.25,52.44 48.08,52.27 45.17,52.27 44.6,51.7 40.92,51.7 40.37,51.15 33.72,51.15 31.63,49.07 24.51,49.07 23.87,48.44 v2(23.87,47.59) 22.71,47.59 19.7,44.58 19.7,42.2 ; v2(151.98,103.77) 151.41,104.34 151.41,105.37 147.9,108.88 134.62,108.88 134.52,108.98 v2(134.49,108.98)
  IN3 w0.135: v2(149.66,96.25) 149.97,95.93 149.97,92.64 149.66,92.32 149.66,91.8 146.33,88.47 146.33,86.04 145.64,85.35 145.64,80.9 144.64,79.89 144.64,71.16 146.74,69.06 146.74,66.01 146.43,65.7 146.43,61.3 v2(145.44,60.31)
  BOTTOM w0.102: v2(130.32,108.96) 130.47,108.96 130.95,108.48 UC1.J3
  BOTTOM w0.112: v2(149.66,96.25) 149.66,101.51 v1(150.91,102.77) 150.98,102.77 v2(151.98,103.77)
M2280_PCIE_SATA#: length 229.6
  IN1 w0.119: v2(12.99,46.66) 13.41,47.08 21.12,47.08 23.39,49.34 31.53,49.34 33.59,51.41 40.25,51.41 41.5,52.67 52.24,52.67 52.47,52.44 59.03,52.44 61.77,55.17 63.14,55.17 63.89,55.93 69.15,55.93 69.89,55.18 72.24,55.18 73.3,56.25 73.3,62.81 72.8,63.32 72.8,65.27 73.73,66.2 139.62,66.2 142.82,63 143.89,63 145.44,61.45 v2(145.44,60.92)
  IN2 w0.124: v2(148.31,111.85) 148.62,111.85 148.92,111.54 148.92,109.73 148.66,109.47 148.66,106.51 148.39,106.23 148.39,104.51 v2(147.85,103.97)
  IN3 w0.135: v2(145.44,60.92) 146.18,61.66 146.18,65.85 146.51,66.18 146.51,68.96 144.4,71.07 144.4,79.99 145.39,80.98 145.39,85.48 146.02,86.12 146.02,88.56 149.38,91.91 149.38,92.37 149.74,92.73 149.74,95.24 149.26,95.72 149.26,96.59 149.52,96.85 149.52,98.89 v2(148.36,100.05)
  BOTTOM w0.076: UC1.G4 130.71,109.68 130.71,109.67 131.18,109.46 132.71,109.46 133.5,110.25 133.5,110.45
  BOTTOM w0.102: v2(12.99,46.66) 12.31,46.66 v1(12.17,46.51) 11.95,46.29 JNGFF3.69
  BOTTOM w0.112: 133.5,110.45 133.76,110.7 135.08,110.7 135.23,110.55 140.05,110.55 140.98,109.97 144.49,109.97 145.26,110.74 RPC4.4 146.42,110.74 147.52,111.85 v2(148.31,111.85) ; v2(147.85,103.97) 147.85,103.57 148.61,102.8 148.61,100.21 148.45,100.05 v2(148.36,100.05)
M3042_DEVSLP: length 181.6
  IN1 w0.119: v2(235.74,102.5) 237.65,100.58 237.65,93.56 238.48,92.73 238.48,89.12 237.77,88.41 237.77,85.61 238,85.38 238,84.24 238.59,83.64 239.04,83.64 239.86,82.82 239.86,81.84 240.73,80.97 240.73,75.5 242.53,73.7 242.53,72.02 v2(242.72,71.83)
  IN2 w0.124: v2(149.92,105.28) 150.37,104.84 150.37,101.36 154.51,97.22 154.51,93.03 156.23,91.3 163.52,91.3 167.33,87.49 167.33,84.85 169.7,82.48 169.7,79.51 171.19,78.02 171.19,73.69 171.67,73.2 175.72,73.2 180.04,68.88 184.33,68.88 186.09,67.12 205.23,67.12 206.58,65.77 226.08,65.77 227.44,67.13 230.54,67.13 231.07,66.61 232.66,66.61 235.05,69 236.36,69 236.82,69.45 240.05,69.45 242.42,71.83 v2(242.72,71.83)
  BOTTOM w0.076: UC1.J2 131.91,108.48 132.27,108.22 133.08,108.22 133.45,108.6 133.45,109.08 133.76,109.38 134.87,109.38
  BOTTOM w0.112: v2(149.92,105.28) 149.59,104.96 v1(148.66,104.96) 146.25,104.96 145.72,104.42 144.73,104.42 144.15,105 144.15,107.16 142.39,108.93 140.79,108.93 139.79,109.38 134.87,109.38 ; JNGFF2.30 v2(235.74,102.5)
M3042_PCIE#_SATA: length 195.7
  TOP w0.107: v2(253.48,93.06) UE1.J12
  IN2 w0.124: v2(144.46,107.96) 144.24,107.75 144.24,102.91 144.55,102.6 144.55,102.4 146.48,100.47 147.55,100.47 147.8,100.72 149.4,100.72 151.48,98.64 151.48,93.08 153.98,90.58 163.23,90.58 166.65,87.15 166.65,84.57 169.02,82.2 169.02,79.22 170.51,77.74 170.51,73.41 171.39,72.53 175.44,72.53 179.76,68.21 184.04,68.21 185.82,66.43 204.02,66.43 205.36,65.09 226.35,65.09 227.72,66.46 230.25,66.46 230.78,65.93 232.94,65.93 235.33,68.32 236.64,68.32 237.1,68.78 240.33,68.78 242.32,70.76 242.85,70.76 243.4,71.31 244.7,71.31 245.31,71.92 248.8,71.92 249.42,72.54 252.03,72.54 253.36,73.87 257.93,73.87 258.33,73.47 260.15,73.47 260.98,74.31 262.33,74.31 262.83,74.8 262.83,75.96 263.49,76.63 263.49,80.15 262.41,81.23 262.41,83.2 261.99,83.62 261.99,86.23 261.01,87.21 259.61,87.21 258.52,88.3 258.52,90.79 256.64,92.67 254.07,92.67 253.69,93.06 v2(253.48,93.06)
  BOTTOM w0.076: 134.85,109.69 134.64,109.69 134.54,109.59 133.7,109.59 132.87,108.75 132.33,108.75 132.19,108.71 131.94,108.71 131.85,108.74 131.19,108.74 UC1.H3
  BOTTOM w0.112: v2(144.46,107.96) RC412.2 145.17,108.18 144.87,108.48 143.65,108.48 v1(143.28,108.85) 142.92,109.21 140.81,109.21 140,109.69 134.85,109.69
MASK_BASE_LEDS#: length 5.9
  TOP w0.112: v1(265.13,85.78) 265.49,86.13 UZ10.4 267.03,86.13 267.36,85.8 267.36,83.2 267.04,82.88 QZ7.5
ME_FW_EC: length 47.9
  TOP w0.107: UE1.G12 v2(251.08,93.06)
  IN1 w0.119: v2(250.09,101.29) 250.09,98.5 250.18,98.4 250.18,97.05 250.68,96.54 250.68,93.46 v2(251.08,93.06)
  IN2 w0.124: v2(232.1,88.23) 231.61,88.72 231.61,94.5 233.7,96.59 237.51,96.59 238.42,95.69 239.52,95.69 241.93,98.11 243.15,98.11 244.69,99.64 245.16,99.64 246.42,100.9 249.69,100.9 v2(250.09,101.29)
  BOTTOM w0.112: v2(232.1,88.23) 231.88,88.45 v1(231.57,88.45) 231.37,88.45 RC221.1 228.73,87.77 226.85,85.89 226.85,83.87 227.04,83.61 SW1.1
ME_FWP: length 150.9
  TOP w0.112: v2(141.27,76.95) v1(139.88,76.95) 125.68,76.95 RC223.1 ; v2(232.1,85.86) 228.8,82.56 228.8,74.71 227.67,73.58 227.67,71.16 227.42,70.91 226.17,70.91 225.6,70.34 221.02,70.34 v2(220.4,70.96)
  IN2 w0.124: v2(141.27,76.95) 142.95,75.27 142.95,74.21 145.01,72.15 145.01,71.33 148.56,67.78 149.1,67.78 149.44,67.43 158.26,67.43 161.78,63.91 168.1,63.91 171.55,60.46 181.5,60.46 181.79,60.16 199.92,60.16 203.66,56.42 206.77,56.42 208.41,54.79 212.42,54.79 213.19,55.56 214.75,55.56 216.94,57.75 218,57.75 219.03,56.72 v2(219.11,56.72)
  BOTTOM w0.112: SW1.3 v2(232.1,85.86) 232.1,86.8 231.52,87.38 ; v2(219.11,56.72) 218.88,56.94 218.88,68.7 220.4,70.22 v2(220.4,70.96)
ME_RESET#: length 5
  BOTTOM w0.112: RC225.1 RC227.1 150.39,116.61 150.39,115.64 150.71,115.33 UC12.2 152.26,115.33 v1(152.58,115.64)
ME_SUS_PWR_ACK: length 180.7
  TOP w0.107: UE1.B13 247.37,93.57 247.37,94.04 v2(247.1,94.31)
  TOP w0.112: RC74.1 143.53,85.05 v2(143.53,85.53) 143.14,85.53 v1(142.92,85.75)
  IN2 w0.124: v2(143.53,85.53) 143.53,85.56 143.94,85.96 144.3,85.96 145.08,85.18 145.08,83.58 148.44,80.23 148.44,72.5 150.27,70.67 150.59,70.67 151.13,70.14 159.64,70.14 163.16,66.62 172.79,66.62 174.83,64.58 175.87,64.58 176.27,64.98 182.47,64.98 184.46,63 202.3,63 204.56,60.74 218.08,60.74 218.96,61.61 226.06,61.61 226.93,60.74 234.83,60.74 235.14,61.05 236.86,61.05 237.75,60.16 239.08,60.16 241.91,62.99 242.66,62.99 244.43,64.76 244.43,65.4 246.25,67.22 246.25,68.08 245.85,68.49 v2(245.62,68.49)
  IN3 w0.135: v2(143.53,85.53) 142.25,86.82 137.69,86.82 133.76,90.75 129.14,90.75 126.99,92.9 126.99,94.37 126.78,94.58 125.04,94.58 v2(124.78,94.84)
  BOTTOM w0.076: UC1.AR13 124.92,94.84 v2(124.78,94.84)
  BOTTOM w0.112: v2(247.1,94.31) 247.1,93.55 246.09,92.53 246.09,86.21 245.68,85.8 245.68,84.99 245.32,84.63 245.32,83.68 246.63,82.37 246.63,81.27 247.64,80.26 247.64,77.89 246.89,77.14 246.89,76.37 247.53,75.72 247.53,71.57 246.43,70.47 246.43,69.67 245.62,68.86 v2(245.62,68.49)
MEC_XTAL1: length 5.6
  TOP w0.112: YE1.1 242.44,82.2 243.25,83.02 CE28.1 244.4,83.02 244.73,82.69 245.05,82.69 246.21,83.86 UE1.A1
MEC_XTAL2: length 2.8
  TOP w0.112: RE290.2 CE29.1 243.18,83.95 242.42,84.7 YE1.2
MEC_XTAL2_R: length 2.4
  TOP w0.112: UE1.A3 246.09,84.86 RE290.1
MEDIACARD_IRQ#: length 179.1
  TOP w0.112: v2(260.64,72.37) 261.3,72.37 v1(261.73,71.94) 263.17,70.49 263.17,69.38 263.01,69.22 263.01,68.75 264.17,67.58 269.2,67.58 270.23,68.62 RR19.1 272.85,68.36 273.87,67.34 UR1.32
  IN2 w0.124: v2(260.64,72.37) 259.74,72.37 259.37,71.99 258.29,71.99 257.63,72.65 256.76,72.65 256.32,72.22 255.93,72.22 255.54,71.82 252.81,71.82 252.55,71.57 249.73,71.57 249.15,71 245.73,71 245.01,70.27 243.83,70.27 243.24,69.68 242.78,69.68 240.61,67.51 240.61,67.07 240.16,66.63 237.91,66.63 236.11,64.83 230.32,64.83 229.65,65.51 228.57,65.51 227.21,64.15 205.02,64.15 203.65,65.52 185.45,65.52 183.67,67.3 179.38,67.3 175.15,71.54 170.24,71.54 168.9,72.87 168.9,78.06 168.12,78.85 168.12,81.82 165.75,84.19 165.75,86.78 163.93,88.6 160.87,88.6 160.21,89.26 153.39,89.26 152.22,90.43 150.03,90.43 149.11,91.34 149.11,94.52 148.65,94.97 148.65,95.29 148.5,95.44 v2(148.5,95.72)
  IN3 w0.135: v2(127.51,96.71) 127.89,97.09 130.24,97.09 131.94,95.39 144.75,95.39 144.92,95.22 146.35,95.22 146.85,95.72 v2(148.5,95.72)
  BOTTOM w0.076: v2(127.51,96.71) 127.81,96.4 UC1.AN8
MEM_INTERLEAVED: length 9.8
  BOTTOM w0.076: 136.85,106.69 134.09,106.69 v1(133.79,106.4) 133.48,106.08 132.3,106.08 UC1.P2
  BOTTOM w0.112: 136.85,106.69 139.42,106.69 RC371.1 RC372.1
MEM_SMBCLK: length 25
  TOP w0.112: v2(149.7,108.84) 149.7,108.84 149.5,108.65 144.13,108.65 143.77,108.28 140.6,108.28 138.84,106.52 136.12,106.52 135.35,105.75 135.35,105.39 135.23,105.28 134.96,105.28 RC12.1 133.31,104.84 CC320.1 132.99,104.52 132.99,104.52 132.74,104.28 129.49,104.28 129.21,104.56 129.21,104.67 v2(129.39,104.85)
  BOTTOM w0.102: UC1.R7 v2(129.39,104.85)
  BOTTOM w0.112: QC2.6 149.34,109.75 149.71,109.38 149.71,108.85 v2(149.7,108.84)
MEM_SMBDATA: length 25.8
  TOP w0.112: v2(128.8,104.84) 128.97,104.67 128.97,104.46 129.39,104.04 132.84,104.04 133.08,104.28 134.85,104.28 RC14.1 135.58,105.01 135.58,105.65 136.22,106.28 138.94,106.28 140.7,108.05 143.87,108.05 144.23,108.41 149.85,108.41 150.28,108.84 v2(150.29,108.84)
  BOTTOM w0.102: UC1.R8 v2(128.8,104.84)
  BOTTOM w0.112: v2(150.29,108.84) 150.3,108.84 150.69,108.45 QC2.3
MPHYP_PWR_EN: length 22.1
  TOP w0.112: RC387.1 141.09,86.23 139.62,86.23 138.69,87.16 137.11,87.16 130.11,94.16 130.11,94.94 129.64,95.41 129.06,95.41 v1(128.79,95.68) 127.24,95.68 127,95.92 127,96.2 v2(126.5,96.7)
  BOTTOM w0.102: UC1.AM10 126.89,97.05 126.53,96.7 v2(126.5,96.7)
MSCLK: length 87
  TOP w0.112: UE1.H10 v2(252.68,91.46)
  IN3 w0.135: v2(289.98,123.86) 290.41,123.43 290.41,123.07 290.16,122.82 289.17,122.82 v2(287.7,121.36) 287.17,121.89 287.17,122.45 286.4,123.22 286.4,128.49 285.28,129.61 258.74,129.61 251.41,122.29 251.41,117.36 250.61,116.56 250.61,114.01 248.55,111.95 248.55,97.94 250.52,95.96 250.52,95.06 251.92,93.66 251.92,92.22 v2(252.68,91.46)
  BOTTOM w0.112: RE30.1 v2(287.7,121.36) RE72.2 ; v2(289.98,123.86) 290,123.84 JDEG1.6
MSDATA: length 88
  TOP w0.112: UE1.G9 v2(251.08,90.66) ; v3(289.34,120.8) 289.34,122.64 v2(289.97,123.26)
  IN3 w0.135: v2(289.97,123.26) v2(287.74,123.26) 287.49,123.01 286.98,123.01 286.66,123.33 286.66,128.6 285.39,129.88 258.63,129.88 251.15,122.39 251.15,117.47 250.35,116.67 250.35,114.11 248.28,112.05 248.28,97.83 250.26,95.85 250.26,94.95 251.66,93.55 251.66,91.23 v2(251.08,90.66)
  BOTTOM w0.112: RE86.1 v2(287.74,123.26) RE75.2 ; v2(289.97,123.26) 290.04,123.34 JDEG1.7
NB_PSID: length 8.5
  TOP w0.254: PD4.3 PD4.2 38.7,123.59 PL3.2 38.8,122.83 v2(39.44,122.18)
  BOTTOM w0.102: PJPDC1.1 v3(38,124.15)
  BOTTOM w0.254: v2(39.44,122.18) 39.08,122.55 PJPDC1.1
NRB_BIT: length 13.5
  TOP w0.112: v2(128.4,94.02) 128.4,92.49 v1(134.28,86.61) 134.83,86.05 RC186.1
  BOTTOM w0.076: v2(128.4,94.02) 128.4,94.66 128.84,95.1 UC1.AR7
NTC_IA: length 2.6
  TOP w0.203: PR635.2 54.38,92.8 53.99,93.19 53.99,93.5 53.69,93.79 53.34,93.79 53.16,93.97 PU602.15
NVME_LED#: length 11.5
  TOP w0.112: RN100.1 v2(25.17,50.56) v1(25.17,49.9)
  IN3 w0.076: JNGFF3.10 26.7,42.17
  IN3 w0.135: v2(25.17,50.56) 25.93,49.79 25.93,44.11 26.7,43.34 26.7,42.17
ONE_DIMM#: length 11.3
  BOTTOM w0.076: UC1.AP7 128.84,96.01 128.95,96.12 128.96,96.12 129.12,96.29 129.12,96.29 129.56,96.73 130.1,96.73 130.22,96.86 130.63,96.86 130.78,96.71 130.78,96.38 130.96,96.2 134.69,96.2 134.87,96.02 135.27,96.02 135.55,96.29
  BOTTOM w0.112: RC267.1 137.92,97.22 RC268.1 136.47,97.22 135.55,96.29
OTGEN/CMIN: length 4.3
  TOP w0.203: PU901.20 53.8,57.24 53.61,57.42 v1(53.38,57.42)
  TOP w0.254: PR960.2 PR919.2 51.54,58.37 52.48,57.42 v1(53.38,57.42)
PANEL_BKEN_EC: length 260.9
  TOP w0.107: UE1.J9 v2(253.48,90.66)
  TOP w0.112: v1(75.46,121.42) 75.46,121.72 DV2.2 73.56,123.63 73.56,125.39 v2(73.86,125.69)
  IN2 w0.124: v2(257.63,74.97) 257.17,75.43 255.68,75.43 255.48,75.23 251.45,75.23 249.99,73.77 248.97,73.77 248.74,73.54 245.88,73.54 245.12,74.31 241.42,74.31 238.34,71.22 236.92,71.22 235.87,70.18 234.46,70.18 233.05,68.77 231.76,68.77 231.34,68.35 226.99,68.35 226.31,67.68 223.11,67.68 222.49,67.05 207.08,67.05 205.79,68.34 186.54,68.34 184.82,70.07 180.9,70.07 170.91,80.06 170.91,83.02 168.54,85.39 168.54,87.95 166.18,90.31 166.18,105.3 161.54,109.94 161.54,116.87 159.36,119.05 159.36,121.01 154.35,126.02 148.14,126.02 147.15,127.01 146.14,127.01 144.61,128.54 140.92,128.54 140.36,129.1 139.1,129.1 138.68,128.69 131.98,128.69 130.71,129.95 127.17,129.95 126.59,129.38 124.69,129.38 123.98,130.08 122.35,130.08 122.15,129.88 118.18,129.88 117.91,129.61 108.73,129.61 108.23,129.1 104.65,129.1 104.15,129.6 83.61,129.6 80.21,126.2 74.38,126.2 v2(73.86,125.69)
  BOTTOM w0.112: v2(253.48,90.66) 253.88,91.05 255.89,91.05 256.58,90.36 256.58,86.99 257.48,86.09 257.48,85.46 258.5,84.44 258.5,81.51 258.03,81.05 258.03,79.72 257.16,78.85 257.16,77.44 257.91,76.69 257.91,75.24 v2(257.63,74.97)
PANEL_BKLEN: length 91
  TOP w0.112: DV2.3 74.93,123.98 v1(75.73,123.18) 76.08,122.83 v2(76.08,122.64)
  IN2 w0.124: v2(125.7,104.81) 126.37,104.15 130.41,104.15 131.97,105.71 131.97,112.66 134.33,115.02 134.33,117.94 133.04,119.23 133.04,121.19 133.48,121.63 133.48,124.87 132.91,125.43 122.4,125.43 121.38,126.45 120.87,126.45 120.41,125.99 118.33,125.99 117.52,125.18 105.03,125.18 104.93,125.08 98.96,125.08 97.67,123.79 86.31,123.79 85.17,122.65 82.08,122.65 81.44,122.01 76.71,122.01 v2(76.08,122.64)
  BOTTOM w0.076: UC1.R12 125.7,105.25 v2(125.7,104.81)
PANEL_ID: length 13.6
  TOP w0.107: CE47.1 RE300.2 ; UE1.J10 v2(253.48,91.46)
  TOP w0.112: v2(254.05,99.48) 254.89,99.48 255.27,99.86 256.13,99.86 v1(256.3,99.69) 256.3,99.45 255.93,99.08 CE47.1
  IN1 w0.119: v2(254.05,99.48) 254.05,98.74 253.54,98.23 253.54,96.35 253.26,96.07 253.26,93.56 253.06,93.36 253.06,91.88 v2(253.48,91.46)
PBAT_CHARGER_SMBCLK: length 282.5
  TOP w0.112: PD2.3 166.84,62.25 166.84,61.83 166.66,61.65 166.66,60.26 166.99,59.93 167.39,59.93 v2(167.57,59.76) 167.74,59.93 167.95,59.93 168.26,60.24 168.26,60.7 PRP1.3 ; UE1.N2 256.37,84.57 256.87,84.57 257.31,84.12 257.31,83.77 258.75,82.33 259.09,82.33 RE43.1 259.55,81.86 260.06,81.35 260.06,80.78 260.41,80.43 263.49,80.43 263.79,80.13 263.79,78.23 263.42,77.86 263.19,77.86 v2(263.08,77.98) ; PR922.1 50.23,56.91 49.95,56.91 49.76,56.72 49.76,54.7 51.05,53.41 51.71,53.41 52.48,52.65 v4(52.48,52.12) 52.48,51.76 52.92,51.32 54.02,51.32 54.37,50.98 54.37,50.54 v2(54.54,50.37)
  IN1 w0.119: v2(167.57,59.76) 167.4,59.93 167.12,59.93 166.72,59.53 165.53,59.53 164.9,58.9 159,58.9 158.26,59.63 157.28,59.63 157.05,59.86 149.06,59.86 148.74,60.18 146.42,60.18 145.88,59.63 144.82,59.63 143.64,60.82 142.52,60.82 141.22,62.11 141.22,63.49 139.21,65.5 74.15,65.5 73.56,64.91 73.56,63.7 74.07,63.19 74.07,55.9 72.66,54.49 69.61,54.49 68.89,55.22 65.31,55.22 62.49,52.39 61.75,52.39 59.99,50.63 55.16,50.63 54.96,50.84 54.47,50.84 54.37,50.73 54.37,50.53 v2(54.54,50.37)
  IN3 w0.135: v2(263.08,77.98) 263.09,77.98 263.51,77.56 263.51,77.19 262.99,76.67 262.99,75.01 262.55,74.57 261.43,74.57 259.72,72.87 259.72,71.94 259.16,71.38 253.5,71.38 250.67,68.55 250.67,65.7 246.56,61.59 246.56,60.68 246.28,60.4 246.28,57.61 247.76,56.12 247.76,54.44 244.25,50.93 230.77,50.93 228.81,52.88 225.65,52.88 224.28,54.26 223.23,54.26 222.27,55.22 218.12,55.22 217.38,55.96 217.11,55.96 216.55,56.53 210.74,56.53 210.17,55.95 203.38,55.95 200.93,58.4 196.52,58.4 195.77,59.15 183.16,59.15 181.72,57.72 180.88,57.72 180.46,58.14 180.46,59.32 180.21,59.56 177.68,59.56 177.32,59.92 167.73,59.92 v2(167.57,59.76)
PBAT_CHARGER_SMBDAT: length 285.4
  TOP w0.112: PD1.2 167.42,62.51 167.09,62.18 167.09,61.74 166.9,61.55 166.9,60.36 167.09,60.17 167.39,60.17 v2(167.57,60.34) 167.74,60.17 167.85,60.17 168.02,60.34 168.02,61.17 PRP1.2 ; v2(263.08,77.39) 263.31,77.62 263.52,77.62 264.03,78.13 264.03,80.22 263.59,80.67 260.51,80.67 260.31,80.87 260.31,81.81 RE37.1 260.51,82.62 258.86,82.62 257.57,83.92 257.57,84.21 256.95,84.83 256.75,84.83 256.53,85.06 255.88,85.06 UE1.M3 ; PR920.1 50.23,57.15 49.85,57.15 49.52,56.82 49.52,54.61 50.95,53.18 51.61,53.18 52.24,52.55 52.24,51.66 52.82,51.08 53.93,51.08 54.13,50.88 54.13,50.54 v2(53.95,50.37)
  IN1 w0.119: v2(167.57,60.34) 167.4,60.17 167.02,60.17 166.62,59.78 165.43,59.78 164.79,59.14 159.1,59.14 158.36,59.88 157.38,59.88 157.15,60.11 149.16,60.11 148.84,60.42 146.32,60.42 145.78,59.88 144.92,59.88 143.74,61.06 142.62,61.06 141.47,62.22 141.47,63.59 139.31,65.74 74.04,65.74 73.31,65.01 73.31,63.6 73.82,63.09 73.82,56 72.56,54.74 69.71,54.74 68.99,55.46 65.21,55.46 62.39,52.64 61.64,52.64 59.88,50.88 55.26,50.88 55.06,51.08 54.37,51.08 54.13,50.84 54.13,50.54 v2(53.95,50.37)
  IN3 w0.135: v2(263.08,77.39) 262.73,77.04 262.73,75.12 262.44,74.84 261.32,74.84 259.46,72.97 259.46,72.05 259.05,71.64 253.39,71.64 250.41,68.66 250.41,65.81 246.29,61.69 246.29,60.79 246.02,60.51 246.02,57.5 247.5,56.02 247.5,54.54 244.14,51.19 230.88,51.19 228.92,53.15 225.76,53.15 224.38,54.52 223.34,54.52 222.38,55.48 218.23,55.48 217.49,56.23 217.22,56.23 216.66,56.79 210.64,56.79 210.06,56.21 203.49,56.21 201.04,58.66 196.63,58.66 195.88,59.41 183.05,59.41 181.62,57.98 180.99,57.98 180.72,58.25 180.72,59.43 180.32,59.83 177.79,59.83 177.43,60.18 167.73,60.18 v2(167.57,60.34)
PBAT_PRES#: length 265.2
  TOP w0.112: PR931.1 53.94,51.99 55.8,50.13 v1(59.71,50.13) 62.83,50.13 v2(62.85,50.15) ; v2(162.3,56.25) 162.84,56.78 162.84,63.13 163.28,63.57 164.68,63.57 166.58,65.48 167.22,65.48 168.11,64.58 PR1.2 168.81,64.56 PD1.3 168.05,63.79 168.05,61.9 PRP1.1 ; UE1.F9 v2(250.28,90.66)
  IN1 w0.119: v2(62.85,50.15) 62.85,51.33 65.77,54.25 68.4,54.25 70.08,52.57 71.93,52.57 73.99,50.51 126.52,50.51 129.79,53.78 140.89,53.78 142.16,55.05 144.73,55.05 146.42,56.74 146.42,58.26 147.06,58.91 147.82,58.91 148.86,57.87 150.78,57.87 151.37,58.46 156.62,58.46 158.09,56.98 161.57,56.98 v2(162.3,56.25)
  IN2 w0.124: v2(236.37,81.37) 235.91,81.84 235.91,85.43 237.27,86.79 237.27,87.9 239.62,90.26 249.68,90.26 250.08,90.66 v2(250.28,90.66) ; v2(162.3,56.25) 163.2,55.35 176.22,55.35 178.34,57.47 179.27,57.47 179.98,56.75 182.45,56.75 183.63,57.94 183.63,58.39 183.82,58.58 195.19,58.58 195.9,57.87 199.97,57.87 202.45,55.39 202.45,53.46 202.99,52.92 204.09,52.92 204.6,53.43 213.87,53.43 214.24,53.8 225.69,53.8 226.21,53.28 229.73,53.28 229.82,53.19 230.46,53.19 v2(230.9,53.63)
  BOTTOM w0.112: v2(236.37,81.37) 236.2,81.2 236.2,80.43 235.4,79.63 235.4,72.76 235.4,72.76 235.4,70.4 235.02,70.02 235.02,67.4 235.17,67.26 235.17,65.76 235.66,65.27 235.66,62.66 235.99,62.33 235.99,59.78 233.26,57.05 233.26,55.82 231.07,53.63 v2(230.9,53.63)
PBAT_PRES#_C: length 4.8
  TOP w0.112: 168.62,62.48 168.62,62.49 v2(169.42,63.28) 169.42,64.25 v1(169.99,64.83)
  BOTTOM w0.112: v2(169.42,63.28) 169.21,63.49 168.51,63.49 PBATT1.6
PBAT_SMBCLK_C: length 4
  TOP w0.112: PRP1.6 169.81,62.25 v2(170.6,62.25) v1(171.31,62.25)
  BOTTOM w0.112: v2(170.6,62.25) 170.6,61.34 PBATT1.4
PBAT_SMBDAT_C: length 3.7
  TOP w0.112: v1(170.34,63.35) 170.34,62.99 v2(170.12,62.76) 169.61,62.76 PRP1.7
  BOTTOM w0.112: v2(170.12,62.76) 169.9,62.76 PBATT1.5
PBATT+_C:
  vias: v2(168.27,57.62) v2(168.27,57.04) v2(168.27,56.46) v2(168.56,58.16) v2(168.86,57.62) v2(168.86,57.04) v2(168.86,56.46) v2(169.14,58.16) v2(169.44,57.62) v2(169.44,57.04) v2(169.44,56.46) v2(169.73,58.16) v2(170.02,57.62) v2(170.02,57.04) v2(170.02,56.46) v2(170.61,57.62) v2(170.61,57.04) v2(170.61,56.46) v2(171.19,57.04) v3(167.23,55.61) v3(168.38,54.14) v3(169.32,55.87)
PCH_ALW_ON: length 150.1
  TOP w0.107: UE1.M8 255.48,89.44 255.87,89.06 256.73,89.06 256.88,88.91 257.53,88.91 257.99,89.37 v2(257.99,89.39)
  TOP w0.112: v1(160.65,61.77) 160.82,61.77 v2(161.14,61.45) 161.14,61 RZ65.1 ; v2(259.77,97.83) 259.68,97.92 RPE10.3
  IN2 w0.124: v2(161.14,61.45) 161.34,61.25 165.08,61.25 165.54,61.72 169.57,61.72 171.28,60.01 180.34,60.01 180.96,59.39 182.61,59.39 182.93,59.71 199.73,59.71 203.54,55.9 206.36,55.9 207.92,54.34 213.5,54.34 213.89,54.73 224.19,54.73 224.22,54.7 226.07,54.7 226.28,54.49 233.45,54.49 233.74,54.78 234.45,54.78 237.1,57.42 242.82,57.42 244.85,59.46 244.85,60.34 249.4,64.88 251.66,64.88 252.68,65.9 255.78,65.9 256.08,66.2 259.08,66.2 260.46,67.58 v2(260.65,67.58)
  BOTTOM w0.112: v2(259.77,97.83) 259.21,97.27 258.09,97.27 256.42,95.59 256.42,91.73 257.99,90.16 v2(257.99,89.39) 257.99,89.27 258.99,88.26 258.99,87.21 260.06,86.15 260.06,85.07 260.17,84.96 260.17,79.19 259.85,78.87 259.85,77.39 259.33,76.87 259.33,76.36 259.47,76.23 259.47,71.8 258.88,71.21 258.88,69.86 260.32,68.41 260.32,67.91 v2(260.65,67.58)
PCH_BATLOW#: length 13.2
  TOP w0.112: RC72.1 131.02,85.55 v1(130.68,85.89) 130.01,86.56 130.01,90.07 127.86,92.22 127.84,92.22 127.21,92.86 125.35,92.86 124.79,93.42 v2(124.79,93.47)
  BOTTOM w0.076: v2(124.79,93.47) 124.85,93.47 UC1.AU13
PCH_CL_CLK1: length 177.2
  TOP w0.112: v2(237.82,70.8) 237.59,70.57 233.53,70.57 232.66,71.45 230.79,71.45 v1(229.27,69.93) 228.25,68.91 227.06,68.91 226.32,68.17 217.47,68.17 215.6,70.04 v2(215.6,70.97)
  BOTTOM w0.076: UC1.G3 130.77,110.15 130.33,110.15 130.15,110.32 130.15,110.75 130.76,111.36 131.24,111.36 131.3,111.3 131.56,111.3 131.62,111.37 132.74,111.37
  BOTTOM w0.112: JNGFF1.42 240.27,70.4 239.93,70.06 238.56,70.06 v2(237.82,70.8) ; v2(215.6,70.97) 216.94,72.3 216.94,74 216.28,74.66 215,74.66 213.56,73.79 211.3,72.76 210.39,72.43 210.39,71.36 209.98,70.95 185.77,70.95 170.73,86 170.73,90.69 168.55,92.87 168.55,101.38 166.57,103.36 166.57,106.65 165.79,107.43 165.79,108.98 163.82,110.96 163.82,120.73 162.51,122.04 154.1,122.04 152.76,120.7 152.76,117.84 153.48,117.13 153.48,113.53 152.75,112.8 147.01,112.8 146.14,113.68 146.14,115.45 143.94,117.65 138.54,117.65 135.75,114.86 135.75,112.39 134.77,111.42 132.79,111.42 132.74,111.37
PCH_CL_DATA1: length 176.2
  TOP w0.112: v2(215,70.97) 215,70.13 v1(216.54,68.6) 217.2,67.93 226.46,67.93 227.22,68.7 231.03,68.7 231.27,68.93 233.89,68.93 235.3,70.34 237.95,70.34 v2(238.4,70.8)
  BOTTOM w0.076: UC1.G2 131.76,109.81 132.1,110.15 132.74,110.15 133.02,110.42
  BOTTOM w0.112: 133.02,110.42 133.02,110.75 133.45,111.19 134.92,111.19 136,112.27 136,114.73 138.67,117.4 143.81,117.4 145.88,115.33 145.88,113.55 146.9,112.53 152.86,112.53 153.75,113.42 153.75,117.24 152.98,118.01 152.98,120.61 154.19,121.82 162.42,121.82 163.6,120.64 163.6,110.87 165.58,108.9 165.58,107.34 166.36,106.56 166.36,103.21 168.29,101.28 168.29,92.79 170.49,90.59 170.49,85.88 171.91,84.47 171.91,84.31 171.63,84.03 171.63,83.88 171.79,83.72 171.95,83.72 172.22,83.99 172.38,83.99 172.54,83.83 172.54,83.68 172.26,83.4 172.26,83.24 172.42,83.09 172.58,83.09 172.85,83.36 173.01,83.36 185.65,70.72 210.06,70.72 210.62,71.28 210.62,72.28 211.38,72.55 213.66,73.59 215.06,74.45 216.19,74.45 216.71,73.93 216.71,72.67 v2(215,70.97) ; JNGFF1.40 240.24,70.9 239.68,70.34 238.86,70.34 v2(238.4,70.8)
PCH_CL_RST1#: length 175.5
  TOP w0.112: v2(239.04,70.8) 238.36,70.13 235.56,70.13 234.16,68.72 231.36,68.72 231.12,68.48 227.31,68.48 226.52,67.7 216.95,67.7 v1(214.46,70.19) 214.42,70.23 v2(214.42,70.95)
  BOTTOM w0.076: 133.27,110.35 132.73,109.8 UC1.G1
  BOTTOM w0.112: v2(214.42,70.95) 214.86,71.39 214.89,71.39 216.48,72.99 216.48,73.85 216.1,74.23 215.15,74.23 213.56,73.28 211.43,72.32 210.84,72.12 210.84,71.21 210.13,70.5 185.52,70.5 173.3,82.71 172.49,82.71 170.87,84.33 170.87,84.49 171.15,84.76 171.15,84.92 170.99,85.08 170.83,85.08 170.56,84.8 170.4,84.8 170.25,84.96 170.25,90.5 168.04,92.7 168.04,101.17 166.15,103.07 166.15,106.47 165.37,107.25 165.37,108.81 163.39,110.78 163.39,120.55 162.33,121.61 154.28,121.61 153.19,120.52 153.19,118.18 154.02,117.35 154.02,113.31 152.97,112.26 146.79,112.26 145.63,113.42 145.63,115.2 143.69,117.14 138.77,117.14 136.26,114.63 136.26,112.16 135.03,110.93 133.6,110.93 133.27,110.6 133.27,110.35 ; JNGFF1.38 240.3,71.4 239.7,70.8 v2(239.04,70.8)
PCH_DPWROK: length 201.8
  TOP w0.112: v2(123.09,81.12) 123.22,81.12 123.61,80.73 123.83,80.73 124.57,80 125.27,80 125.79,80.52 RC215.1 125.8,80.5 CC266.1 RC220.1 ; v2(242.9,98.56) UE7.1 241.85,99.43 v3(242.42,100) 242.42,100.3 242.34,100.38 242.34,101.83 241.46,102.7 RE536.2
  IN1 w0.119: v2(123.09,81.12) 123.09,81.67 125.46,84.04 131.52,84.04 v2(132.23,83.32)
  IN2 w0.124: v2(132.23,83.32) 133.76,84.85 134.77,84.85 136.87,86.94 144.3,86.94 145.82,85.43 145.82,83.8 149.35,80.27 149.35,72.93 151.46,70.82 160.3,70.82 163.78,67.35 174.36,67.35 176.03,65.68 182.73,65.68 184.72,63.69 202.68,63.69 204.77,61.59 217.98,61.59 218.68,62.29 226.34,62.29 227.04,61.59 234.72,61.59 234.86,61.73 236.59,61.73 237.5,62.65 237.54,62.65 237.92,63.03 240.99,63.03 241.7,63.74 242.45,63.74 243.66,64.95 243.66,67.14 v2(244.4,67.88)
  BOTTOM w0.076: 123.6,87.26 122.22,88.63 122.22,89.37 121.56,90.03 121.56,90.57 UC1.BB20
  BOTTOM w0.112: 123.6,87.26 123.6,83.2 123.09,82.69 v2(123.09,81.12) ; v2(244.4,67.88) 244.52,68.01 244.52,69.19 245.49,70.16 245.49,70.88 246.68,72.07 246.68,74.91 245.44,76.15 245.44,77.44 246.05,78.04 246.05,78.58 245.49,79.14 245.49,80.14 243.56,82.06 243.56,85.4 243.23,85.74 242.57,85.74 242.42,85.89 242.42,86.8 242.66,87.04 242.66,89.55 243.42,90.31 243.42,98.04 v2(242.9,98.56)
PCH_DPWROK_EC: length 10.9
  TOP w0.112: UE1.F8 v2(250.28,89.86) ; RE34.1 v2(245.07,95.39)
  BOTTOM w0.112: v2(250.28,89.86) 249.88,90.26 249.88,94.02 249.02,94.88 247.8,94.88 247.29,95.39 v2(245.07,95.39)
PCH_JTAG_TCK: length 65.8
  TOP w0.112: RC86.1 97.29,120.1 97.94,119.45 97.94,118.19 v2(98.71,117.42) ; v2(86.38,132.22) 86.3,132.13 v3(86.3,129.91) 86.37,129.83 86.37,128.16 84.31,126.09 81.51,126.09 78.89,123.47 78.89,118.54 77.99,117.64 77.99,113.77 v2(77.17,112.95)
  IN3 w0.135: v2(98.71,117.42) 98.49,117.42 97.04,118.87 91.48,118.87 90.28,117.66 89.64,117.66 88.01,116.04 86.08,116.04 85.27,115.23 85.27,112.28 83.49,110.5 80.35,110.5 80.1,110.25 79.27,110.25 78.07,111.45 78.07,112.05 v2(77.17,112.95)
  BOTTOM w0.076: UC1.B56 100.3,112.87 100.3,113.09 100.24,113.21 100.24,113.47 100.42,113.65 100.42,114.53 100.28,114.68 100.28,115.53 99.91,115.9 99.91,116.22 v2(98.71,117.42)
  BOTTOM w0.112: v2(86.38,132.22) 86.49,132.12 86.49,131.56 87.31,130.73 JXDP1.55
PCH_JTAG_TDI: length 31.5
  TOP w0.112: v3(98.25,117.11) 98.39,117.11 v2(98.71,116.79)
  IN1 w0.119: v2(98.71,116.79) 98.03,116.1 95.59,116.1 95.05,116.65 84.99,116.65 84.03,117.61 81.05,117.61 v2(80.99,117.55)
  BOTTOM w0.076: UC1.D59 99.37,111.69 99.45,111.96 99.45,112.07 99.53,112.35 99.57,112.51 99.59,112.55 99.59,112.8 99.55,112.89 99.55,113.08 99.59,113.18 99.59,113.54 99.43,113.7 99.43,116.07 v2(98.71,116.79)
  BOTTOM w0.102: v2(98.71,116.79) 98.13,117.37 98.13,118.95 98.54,119.36 98.54,119.75 CC304.1 RC81.1
  BOTTOM w0.112: v2(80.99,117.55) 80.99,118.25 80.67,118.57 RC229.2
PCH_JTAG_TDO: length 28.3
  TOP w0.112: v2(84.73,117.55) v3(85.29,117.55)
  IN1 w0.119: v2(84.73,117.55) 85.39,116.9 95.15,116.9 95.69,116.35 97.43,116.35 97.82,116.74 97.82,117.17 v2(98.71,118.06)
  BOTTOM w0.076: 100.16,116.6 100.16,116.03 100.44,115.75 100.44,114.75 100.61,114.58 100.61,113.41 UC1.A56
  BOTTOM w0.102: 100.16,116.6 v2(98.71,118.06) 99.22,118.57 100.1,118.57 100.33,118.79 100.33,119.8 99.91,120.22 CC303.1 RC82.1
  BOTTOM w0.112: RC230.2 84.09,117.68 84.61,117.68 v2(84.73,117.55)
PCH_JTAG_TMS: length 40.1
  TOP w0.112: v2(78.89,117.55) 79.11,117.78 v3(79.11,118.06) ; RC130.1 99.13,120.47 99.13,116.58 v2(98.71,116.15)
  IN1 w0.119: v2(98.71,116.15) 98.71,114.07 97.99,113.35 92.38,113.35 89.57,116.16 84.79,116.16 84.3,116.65 79.79,116.65 v2(78.89,117.55)
  BOTTOM w0.076: v2(98.71,116.15) 99.25,115.61 99.25,113.64 99.42,113.47 99.42,113.21 99.36,113.09 99.36,112.94 99.42,112.75 99.42,112.58 99.34,112.32 UC1.C59
  BOTTOM w0.112: RC228.2 77.48,121.37 78.63,120.22 78.63,117.87 78.89,117.61 v2(78.89,117.55)
PCH_PCIE_WAKE#: length 188.9
  TOP w0.102: UE1.L1 254.68,83.3 v2(254.63,83.25)
  TOP w0.112: v2(135.99,79.84) 136.17,79.84 136.57,79.44 RC67.1 ; RE274.2 259.85,79.08 v2(259.29,79.64)
  IN1 w0.119: v2(254.63,83.25) 254.74,83.25 255.45,82.54 255.45,80.58 256.39,79.64 v2(259.29,79.64)
  IN2 w0.124: v2(258.34,69.48) 258.72,69.1 258.72,68.62 258.09,67.98 252.17,67.98 251.3,67.11 249.7,67.11 249.33,66.74 247.85,66.74 245.79,64.67 245.79,63.27 243.45,60.94 243.45,59.98 242.25,58.78 236.53,58.78 235.34,57.58 226.6,57.58 225.75,58.44 219.19,58.44 218.64,58.98 216.57,58.98 215.47,57.87 208.01,57.87 207.36,58.52 206.49,58.52 205.86,59.15 203.76,59.15 201.62,61.29 182.26,61.29 181.97,61.59 173.97,61.59 170.52,65.04 162.3,65.04 158.78,68.56 150.2,68.56 149.81,68.95 149.4,68.95 146.51,71.84 146.51,72.25 144.25,74.51 144.25,77.68 143.08,78.85 143.08,79.39 142.45,80.01 142.45,82.3 140.77,83.98 136.83,83.98 136.12,83.27 136.12,81.75 136.47,81.39 136.47,80.33 v2(135.99,79.84)
  BOTTOM w0.076: UC1.BB15 123.79,90.6 123.79,89.41 125.46,87.73 125.86,87.73 126.92,86.66
  BOTTOM w0.112: v2(135.99,79.84) 135.56,80.27 135.56,81.34 134.09,82.81 133.82,82.81 132.7,83.93 129.18,83.93 v1(127.38,85.74) 126.92,86.19 126.92,86.66 ; v2(259.29,79.64) 258.8,79.64 257.63,78.47 257.63,77.63 258.37,76.9 258.37,74.61 258.11,74.36 258.11,73.06 258.39,72.78 258.39,69.53 v2(258.34,69.48)
PCH_PLTRST#: length 60.8
  TOP w0.112: v2(148.11,95.26) 148.65,95.26 149.11,95.72 149.68,95.72 149.92,95.48 153.77,95.48 154.66,96.37 154.66,104.5 152.88,106.28 152.88,107.85 153.15,108.11 153.15,113.29 153.79,113.94 v1(153.79,117.19) 153.79,118.16 v2(154.77,119.14)
  IN3 w0.135: v2(148.11,95.26) 147.01,95.26 146.54,94.78 144.71,94.78 144.61,94.88 134.01,94.88 132.05,94.88 130.47,96.45 129.13,96.45 128.87,96.2 128.87,95.87 128.67,95.67 127.89,95.67 v2(127.48,96.07)
  BOTTOM w0.102: v2(127.48,96.07) 127.34,96.07 UC1.AN10
  BOTTOM w0.112: 155.79,119.32 155.61,119.14 v2(154.77,119.14) ; 155.79,119.32 155.98,119.14 UC7.2 ; 155.79,119.32 155.79,119.68 155.91,119.79 UC7.1 157.23,120.34 RC244.1 RC62.1 RC60.1
PCH_PLTRST#_5105: length 24.6
  TOP w0.107: UE1.K1 253.88,83.34 254.56,82.66 v2(254.63,82.66)
  TOP w0.112: v1(270.27,79.11) 270.51,79.35 v2(270.51,79.56) 270.51,80.03 RE340.1 269.98,80.26 269.15,79.43 UE6.4
  IN1 w0.119: v2(270.51,79.56) 269.2,78.26 264.77,78.26 263.82,79.21 262.42,79.21 262.28,79.07 256.18,79.07 255.01,80.24 255.01,82.28 v2(254.63,82.66)
PCH_PLTRST#_AND: length 551.1
  TOP w0.102: UT1.L4 v2(28.39,98.04)
  TOP w0.112: v2(270.81,67.66) 271.51,67.66 272.91,66.27 UR1.1 ; v2(182.57,63.46) 180.54,61.43 180.54,57.41 179.37,56.25 179.37,53.69 181.14,51.93 v2(184.6,51.93) ; 237.46,61.87 236.16,61.87 235.89,61.59 229.01,61.59 v2(228.59,62.01) ; 237.46,61.87 238.33,62.73 v2(238.33,63.69) ; 237.46,61.87 237.48,61.85 237.48,61.24 236.96,60.72 236.22,60.72 235.98,60.48 235.98,59.84 235.65,59.51 235.08,59.51 233.93,60.65 231.52,60.65 231.15,60.29 231.15,59.69 230.08,58.62 227.91,58.62 226.8,59.73 225.14,59.73 224.67,59.26 CZ61.1 RZ114.1 ; v2(155.59,107.8) 155.14,108.25 155.14,113.33 155.86,114.04 155.86,116.45 v2(156.13,116.72)
  IN1 w0.076: JNGFF3.50 16.7,42.11
  IN1 w0.119: v2(25.2,48.59) 31.85,48.59 33.92,50.66 40.48,50.66 41.17,49.97 43.13,49.97 44.3,51.14 51.79,51.14 53.03,49.9 60.76,49.9 65.6,54.73 68.52,54.73 70.26,52.99 72.11,52.99 74.17,50.94 126.29,50.94 129.59,54.24 140.61,54.24 141.96,55.59 144.52,55.59 145.94,57 145.94,58.38 146.88,59.33 148.02,59.33 149.06,58.29 150.61,58.29 151.2,58.89 156.79,58.89 158.27,57.41 162.08,57.41 164.29,55.2 171.75,55.2 172.49,54.46 177.96,54.46 179.91,52.5 184.02,52.5 v2(184.6,51.93) ; v2(232.08,81.9) 228.87,78.69 228.87,78.19 227.65,76.97 v2(227.65,76.49) ; 16.7,42.11 15.94,42.87 14.15,42.87 11.86,45.16 11.86,48.19 14.5,50.84 v2(15.42,50.84) ; v2(228.59,62.01) 227.95,62.65 220.6,62.65 220.14,63.11 185.74,63.11 184.96,63.89 183.01,63.89 v2(182.57,63.46) 182.18,63.46 174.88,70.77 174.06,71.44 173.02,72.48 169.75,72.48 168.45,73.77 168.45,77.8 165.3,81.36 165.3,83.04 164.14,85.48 162.99,85.48 162.76,85.71 162.76,87.82 160.23,90.35 160.23,94.14 158.62,95.76 158.62,101.31 156.91,103.02 156.91,104.87 155.59,106.19 v2(155.59,107.8)
  IN3 w0.135: v2(15.42,50.84) 15.42,51.91 18.06,54.55 19.63,54.55 20.2,55.12 20.2,63.57 23.06,66.43 24.14,66.43 24.43,66.72 24.43,70.71 22.47,72.68 v2(22.47,78.15)
  BOTTOM w0.112: v2(232.08,81.9) 232.56,82.38 232.56,88.38 232.07,88.87 232.07,90.84 232.7,91.48 232.7,94.6 235.01,96.9 235.01,97.61 236.9,99.5 JNGFF2.42 238.63,99.5 238.64,99.49 239.27,99.49 239.55,99.77 239.55,100.82 241.67,102.94 244.73,102.94 245.21,102.46 248.73,102.46 248.96,102.7 252.97,102.7 253.45,103.17 261.22,103.17 261.65,102.74 262.17,102.74 262.59,102.32 264.03,102.32 264.36,101.99 265.33,101.99 266.32,101 266.32,99.2 266.81,98.71 267.57,98.71 270.06,96.22 270.06,94.79 270.67,94.18 270.67,85.97 271.41,85.24 271.41,68.81 270.81,68.22 v2(270.81,67.66) ; v2(15.42,50.84) v1(18.13,50.84) 22.95,50.84 v2(25.2,48.59) ; v2(22.47,78.15) 22.47,78.24 23.63,79.4 25.44,79.4 25.81,79.76 25.81,86.93 26.25,87.37 26.25,88.72 27.98,90.45 27.98,91.26 28.39,91.67 28.39,92.85 26.4,94.84 26.4,96.11 27.01,96.72 27.77,96.72 28.39,97.33 v2(28.39,98.04) ; v2(228.59,62.01) 228.59,62.29 226.56,64.32 226.56,65.95 222.78,69.73 222.78,71.73 227.54,76.49 v2(227.65,76.49) ; JNGFF1.52 239.77,67.9 238.23,66.36 238.23,63.79 v2(238.33,63.69) 238.97,64.34 239.99,64.34 240.05,64.4 JNGFF1.66 ; UC7.4 155.22,118.49 155.33,118.38 RC65.1 156.03,116.72 v2(156.13,116.72) 156.86,116.72 RC325.1
PCH_PLTRST#_EC: length 186.9
  TOP w0.112: v2(155.66,108.46) 155.66,111.04 156.27,111.66 156.27,116 156.65,116.38 v1(156.65,117.28) 156.65,118.01 158.81,120.16 v2(160.02,120.16) ; UE6.2 265.52,80.08 265.19,79.75 265.19,77.4 v2(263.44,75.66)
  IN1 w0.119: v2(263.44,75.66) 263.44,75.26 262.45,74.27 259.44,74.27 258.77,73.61 256.35,73.61 v2(255.9,73.16) 254.51,71.77 251.12,71.77 249.76,70.4 245.69,70.4 244.22,68.94 233.54,68.94 231.87,67.27 231.87,65.39 229.56,63.08 220.94,63.08 220.49,63.54 195.85,63.54 arc(184.38,65.67) 174.43,71.77 173.81,72.32 173.07,73.06 170.97,73.06 170.5,73.53 169.45,73.53 168.88,74.1 168.88,77.96 165.78,81.5 165.78,83.12 arc(164.27,86.51) 163.12,90.04 162.35,91.29 161.17,92.47 161.17,100.93 158.95,103.15 157.92,103.15 157.42,103.65 157.42,104.97 156.02,106.37 156.02,108.1 v2(155.66,108.46)
  BOTTOM w0.112: RE375.2 249.35,55.5 249.35,62.49 252.41,65.55 252.41,67.51 254.15,69.25 254.15,71.29 255.9,73.04 v2(255.9,73.16) ; RC244.2 159.83,120.34 v2(160.02,120.16)
PCH_POPIRCOMP: length 11.2
  TOP w0.381: RC89.1 125.12,84.66 125.75,85.29 v1(125.75,86.57) 125.75,88.25 v2(125.47,88.53)
  IN2 w0.381: v2(122.89,93.66) 123.21,93.33 123.21,92.85 125.47,90.59 v2(125.47,88.53)
  BOTTOM w0.254: v2(122.89,93.66) 123.11,93.63 UC1.AU16
PCH_PWROK: length 166.1
  TOP w0.112: v2(45.87,58.3) 45.49,58.68 44.73,58.68 v3(44.17,59.24) 37.68,65.73 37.68,75.99 39.88,78.19 39.88,80.17 43.93,84.23 43.93,88.49 44.86,89.42 PR614.1 ; RC411.1 122.24,82.38 v2(122.16,82.38)
  IN1 w0.076: v2(122.16,82.38) 121.36,81.58 121.36,80.87
  IN1 w0.119: 121.36,80.87 118.84,78.35 88.76,78.35 79.46,87.65 75.34,87.65 74.7,87.01 v2(74.7,86.75)
  IN3 w0.135: v2(74.7,86.75) 74.7,84.72 75.31,84.11 75.31,73.37 74.08,72.14 74.08,65.81 73.63,65.37 73.63,56.02 73.23,55.61 70.53,55.61 69.95,56.2 62.36,56.2 60.48,54.32 59.19,54.32 58.71,54.8 53.21,54.8 50.15,57.86 46.32,57.86 v2(45.87,58.3)
  BOTTOM w0.076: UC1.BA20 121.18,91.07 121.18,90.51 121.39,90.31 121.39,89.97 122.04,89.32 122.04,88.56 123.34,87.26 123.34,87.13
  BOTTOM w0.112: v2(122.16,82.38) 123.34,83.56 123.34,87.13
PCH_RSMRST#: length 76
  TOP w0.112: RE342.1 v2(261.44,84.12) RE364.2 ; UZ6.1 203.8,59.72 206.17,62.09 211.82,62.09 212.25,61.66 217.18,61.66 218.09,62.57 v1(235.36,62.57) 236.62,62.57 v2(237.74,63.69) ; RE363.2 v2(253.01,79.18)
  IN1 w0.119: v2(253.01,79.18) 253.01,79.07 253.44,78.64 253.44,77.32 249.9,73.77 246.58,73.77 245.08,72.27 v2(244.75,72.27)
  IN3 w0.135: v2(244.75,72.27) 244.75,70.69 243.05,68.99 243.05,65.61 240.7,63.26 237.99,63.26 237.74,63.51 v2(237.74,63.69) ; v2(253.01,79.18) 255.83,82 259.32,82 v2(261.44,84.12)
PCH_RSMRST#_AND: length 112.8
  TOP w0.112: v2(206.2,55.51) 206.2,55.69 v1(204.62,57.26) 204.54,57.34 204.54,58.23 204.73,58.42 UZ6.4 ; RC215.2 125.82,82.81 125.52,83.11 124.77,83.11 124.61,83.27 124.61,85.16 v2(124.99,85.55) ; RC215.2 RC124.1 ; RC215.2 RC75.1 127.04,81.43 128.57,79.9 129.99,79.9 131.19,78.7 135.48,78.7 135.76,78.98 137.41,78.98 137.97,78.43 139.06,78.43 v2(139.55,77.94)
  IN2 w0.124: v2(139.55,77.94) 139.39,77.79 139.39,75.86 143.38,71.87 143.38,70.83 147.98,66.23 148.64,66.23 149.58,65.29 158.2,65.29 160.73,62.76 160.73,61.22 160.98,60.97 165.18,60.97 165.7,61.49 169.44,61.49 171.16,59.78 180.24,59.78 180.85,59.16 182.7,59.16 183.02,59.49 195.67,59.49 196.33,58.82 200.3,58.82 203.61,55.51 v2(206.2,55.51)
  BOTTOM w0.076: 124.1,87.19 124.1,87.31 122.6,88.81 122.6,90.34 122.41,90.53 122.41,90.79 122.46,90.91 122.46,91.05 122.4,91.28 122.4,91.4 122.47,91.61 122.57,91.72 122.67,91.83 UC1.AY17
  BOTTOM w0.112: 124.1,87.19 124.1,86.12 124.67,85.55 v2(124.99,85.55)
PCH_RSMRST#_GPIO204: length 4.2
  TOP w0.107: RE363.1 v1(253.01,81.8) 253.01,82.31 252.68,82.63 252.68,84.28 252.31,84.66 UE1.H2
PCH_RTCRST#: length 221.5
  TOP w0.112: v2(123.86,96.7) 123.39,96.22 123.39,94.62 123.49,94.52 123.49,93.41 123.28,93.2 123.28,93.01 124.33,91.96 125.75,91.96 128.36,89.35 v1(128.36,86.03) 128.36,84.28 127.9,83.82 127.9,83.17 RC57.1 128.31,81.8 CC25.1 129.35,81.35 v2(130.07,81.35) ; JAPS1.9 260.56,106.12 259.97,105.52 259.52,105.52 255.87,101.88 255.87,101.39 255.44,100.96 252.85,100.96 252.41,101.4 252.41,101.9 250.99,103.33 248.64,103.33 RE94.2 247.22,103.2 247.22,100.28 v2(246.81,99.87)
  IN2 w0.124: v2(130.07,81.35) 132.04,81.35 137.11,86.42 144.19,86.42 145.34,85.27 145.34,83.64 148.66,80.32 148.66,72.6 150.37,70.9 150.72,70.9 151.25,70.37 160.02,70.37 163.52,66.87 172.87,66.87 174.93,64.81 175.73,64.81 176.14,65.23 182.55,65.23 184.55,63.22 202.43,63.22 204.63,61.02 218.05,61.02 218.87,61.84 226.15,61.84 226.97,61.02 234.8,61.02 235.05,61.28 236.77,61.28 237.41,61.91 237.5,61.91 237.58,61.99 237.61,61.99 238.15,62.52 241.12,62.52 241.81,63.21 242.56,63.21 244.2,64.85 244.2,65.49 245.62,66.9 v2(245.62,67.91)
  BOTTOM w0.102: UC1.AM16 123.5,97.05 v2(123.86,96.7)
  BOTTOM w0.112: CMOS1.1 129.78,81.35 v2(130.07,81.35) ; v2(245.62,67.91) 245.21,68.31 245.21,68.31 245.21,68.32 245.21,68.86 246.21,69.87 246.21,70.58 247.32,71.69 247.32,75.64 246.66,76.3 246.66,77.22 247.43,77.98 247.43,79.66 245.67,81.42 245.67,81.79 246.06,82.18 246.06,82.6 245.1,83.56 245.1,84.72 245.47,85.08 245.47,85.94 245.83,86.31 245.83,94.08 244.5,95.41 244.5,96.53 245.1,97.13 245.1,98.63 246.34,99.87 v2(246.81,99.87)
PCH_RTCX1: length 25.2
  TOP w0.112: v2(133.35,86.7) 133.83,86.22 v1(133.83,84.54) 133.83,83.58 RC54.2 135.1,82.31 CC23.1 134.81,81.45 YC2.1
  IN1 w0.119: v2(133.35,86.7) 132.36,87.69 129.46,87.69 125.45,91.7 124.03,91.7 122.43,93.31 122.43,96.2 v2(121.99,96.64)
  BOTTOM w0.102: v2(121.99,96.64) 122.4,97.05 UC1.AM18
PCH_RTCX2: length 23.2
  TOP w0.112: RC54.1 RC296.1 v1(132.94,83.58) 132.94,86.09 132.71,86.32 v2(132.71,86.7)
  IN1 w0.119: v2(121.07,96.76) 121.07,96.75 121.54,96.29 121.54,93.35 123.59,91.3 125.22,91.3 129.26,87.26 132.15,87.26 v2(132.71,86.7)
  BOTTOM w0.102: v2(121.07,96.76) 121.37,97.05 UC1.AM20
PCH_RTCX2_R: length 2.6
  TOP w0.112: YC2.2 132.31,81.45 CC26.1 RC296.2
PCH_SMB_ALERT#: length 6.1
  TOP w0.112: RC23.1 132.03,105.36 v1(131.11,105.36) 127.85,105.36 127.66,105.55 v2(127.66,105.85)
  BOTTOM w0.102: v2(127.66,105.85) 127.49,105.85 127.08,105.44 UC1.R10
PCH_SPI_CLK: length 39.8
  TOP w0.112: v2(159.47,96.07) 158.53,95.13 154.79,95.13 153.33,93.67 152.1,93.67 151.03,92.6 148.27,92.6 147.75,93.13 147.12,93.13 146.58,93.66 144.88,93.66 143.57,94.97 140.52,94.97 138.1,92.55 v3(137.26,92.55) 136.74,92.55 135.57,91.39 133.82,91.39 133.29,91.91 v2(133.29,92.55)
  BOTTOM w0.076: UC1.AV2 131.95,93.2 132.25,92.91 132.69,92.91 133.05,92.55 v2(133.29,92.55)
  BOTTOM w0.112: JSPI1.13 163.76,97.91 RC35.1 163.74,97.86 163.17,97.29 162.51,97.29 161.29,96.07 v2(159.47,96.07)
PCH_SPI_CLK_0_R: length 13.9
  TOP w0.112: RPC1.6 157.13,93.48 157.2,93.41 157.35,93.25 157.35,92.97 157.24,92.86 RC29.1 156.96,92.86 156.54,92.45 156.54,92.21 156.32,91.98 154.06,91.98 153.95,92.1 153.95,92.57 v3(154.5,93.12) 154.58,93.2 156.26,93.2 v2(156.3,93.17)
  BOTTOM w0.107: v2(156.3,93.17) 155.68,93.17 155.68,93.17 155.17,93.17 155.06,93.06 155.06,91.8 154.95,91.7 154.74,91.7 154.63,91.8 154.63,92.57 154.42,92.78 154.27,92.78
  BOTTOM w0.112: UC5.6 154.27,92.78
PCH_SPI_CLK_1_R: length 14.6
  TOP w0.112: RC408.2 156.88,98.83 157.14,99.08 157.14,99.66 157.31,99.83 157.31,100.19 157.2,100.3 156.86,100.3 156.71,100.16 v2(156.71,100.09) 156.62,100.19 RC28.1
  BOTTOM w0.107: UC6.6 154.43,98.69 154.53,98.58 154.53,97.83 154.71,97.65 154.85,97.65 154.96,97.76 154.96,98.58 155.07,98.69 155.28,98.69 155.39,98.58 155.39,97.68 155.44,97.63 155.64,97.63 155.81,97.8 155.81,98.58 156.13,98.9 156.13,99.51 156.02,99.62 155.02,99.62 154.91,99.73 154.91,99.94 155.02,100.05 156.02,100.05 156.13,100.15 156.13,100.54 156.24,100.65 156.69,100.65 156.8,100.54 156.8,100.17 v2(156.71,100.09)
PCH_SPI_CLK_2_R: length 2.8
  BOTTOM w0.112: RZ60.2 RZ63.2 159.99,105.95 159.83,106.12 UZ12.19
PCH_SPI_CLK_R1: length 20.6
  TOP w0.112: RC408.1 157.13,97.53 157.13,96.91 v2(157.38,96.66) 157.13,96.41 RPC1.3
  BOTTOM w0.107: v2(157.38,96.66) 157.38,96.86 157.48,96.96 158.24,96.96 158.77,97.5 158.77,100.41
  BOTTOM w0.112: v2(157.38,96.66) 158.33,96.66 158.52,96.85 161.36,96.85 162.44,97.93 RC35.2 162.83,98 163.23,98.41 JSPI1.14 ; 158.77,100.41 v1(158.77,102.7) 158.77,104.38 RZ60.1
PCH_SPI_CS#0: length 61.8
  BOTTOM w0.076: 135.55,94.37 133.07,94.37 133.03,94.33 132.28,94.33 132.07,94.28 131.99,94.2 131.42,94.2 UC1.AU3
  BOTTOM w0.112: 135.55,94.37 135.81,94.37 136.24,93.94 138.85,93.94 140.24,95.34 142.69,95.34 143.03,95.18 146.73,95.18 147.57,94.34 149.14,94.34 v1(150.04,95.24) 150.04,96.34 150.15,96.45 151.17,96.45 151.28,96.56 151.28,96.79 151.17,96.9 150.15,96.9 150.04,97.01 150.04,97.22 150.15,97.34 151.6,97.34 151.71,97.45 151.71,97.67 151.6,97.78 150.15,97.78 150.04,97.9 150.04,98.12 150.15,98.23 151.63,98.23 151.74,98.34 151.74,98.57 151.63,98.68 150.15,98.68 150.04,98.79 150.04,99.01 150.15,99.12 151.63,99.12 151.74,99.24 151.74,99.46 151.63,99.57 150.15,99.57 150.04,99.68 150.04,99.91 150.15,100.02 151.32,100.02 151.43,100.13 151.43,100.35 151.32,100.47 150.15,100.47 150.04,100.58 150.04,100.8 150.15,100.91 151.97,100.91 152.09,100.79 152.09,100.34 152.41,100.02 152.41,96.92 152.53,96.81 155.82,96.81 156.11,97.1 156.68,97.1 156.87,96.91 156.87,96.34 157.04,96.17 158.62,96.17 159.96,94.82 161.46,94.82 161.81,95.17 163.16,95.17 163.74,95.76 RC36.1 164.82,96.91 JSPI1.11
PCH_SPI_CS#0_R1: length 3.5
  BOTTOM w0.112: RC36.2 162.83,95.92 163.21,96.3 163.55,96.3 163.74,96.49 RC37.1 164.43,97.41 JSPI1.12
PCH_SPI_CS#0_R2: length 3.5
  TOP w0.112: v3(162.65,96.34) 162.32,96.02 v2(162.01,96.02)
  BOTTOM w0.112: RC37.2 162.71,96.72 v2(162.01,96.02) 161.31,95.32 UC5.1
PCH_SPI_CS#1: length 64.6
  TOP w0.112: v2(155.84,96.27) 155.35,96.76 155.35,102.56 155.92,103.13 158.23,103.13 159.31,102.06 v2(159.41,102.06)
  BOTTOM w0.076: 135.55,94.14 133.28,94.14 133.27,94.16 132.43,94.16 132.39,94.15 132.26,94.15 132.21,94.09 132.17,94.08 131.98,93.89 UC1.AU2
  BOTTOM w0.112: v2(159.41,102.06) 162.38,102.06 RC32.2 163.33,103.01 164.78,103.01 166.2,101.59 166.2,101.04 166.07,100.91 JSPI1.19 ; v2(155.84,96.27) 155.57,96.53 151.95,96.53 151.62,96.2 151.62,96.09 151.51,95.98 150.7,95.98 150.59,95.87 150.59,95.65 150.7,95.54 151.48,95.54 151.62,95.4 151.62,95.2 151.51,95.09 150.7,95.09 150.59,94.98 150.59,94.75 150.72,94.62 151.51,94.62 151.62,94.5 151.62,94.02 v1(151.62,94.02) 151.62,93.5 151.51,93.39 151.29,93.39 151.17,93.5 151.17,94.02 151.06,94.13 150.85,94.13 150.74,94.02 150.74,93.5 150.63,93.39 150.4,93.39 150.29,93.5 150.29,94.02 150.18,94.13 149.96,94.13 149.84,94.02 149.84,93.5 149.73,93.39 149.51,93.39 149.4,93.5 149.4,94.02 149.28,94.13 149.07,94.13 148.96,94.02 148.96,93.67 148.85,93.56 148.62,93.56 148.51,93.67 148.51,94.02 148.4,94.13 148.18,94.13 148.07,94.02 148.07,93.65 147.95,93.53 147.73,93.53 147.62,93.65 147.62,94.02 147.51,94.13 147.29,94.13 147.18,94.02 147.18,93.7 147.07,93.58 146.86,93.58 146.73,93.71 146.73,94.85 146.62,94.97 146.42,94.97 146.31,94.85 146.31,93.72 146.2,93.61 145.98,93.61 145.87,93.72 145.87,94.85 145.75,94.97 145.53,94.97 145.42,94.85 145.42,93.72 145.31,93.61 145.08,93.61 144.97,93.72 144.97,94.85 144.86,94.97 144.64,94.97 144.52,94.85 144.52,94.33 144.41,94.22 144.19,94.22 144.08,94.33 144.08,94.85 143.97,94.97 142.91,94.97 142.58,95.12 140.49,95.12 139.03,93.66 136.19,93.66 135.7,94.14 135.55,94.14
PCH_SPI_CS#1_R1: length 2.7
  BOTTOM w0.112: RC32.1 RC42.1 163.94,101.41 JSPI1.20
PCH_SPI_CS#1_R2: length 2.3
  BOTTOM w0.102: 162.15,101.61 161.77,101.23 161.76,101.23
  BOTTOM w0.112: UC6.1 161.76,101.23 ; 162.15,101.61 RC42.2
PCH_SPI_CS#2: length 52.2
  TOP w0.112: v2(135.28,93.61) 135.67,93.61 135.78,93.72 135.78,94.53 135.89,94.64 136.11,94.64 136.22,94.53 136.22,93.72 136.34,93.61 136.56,93.61 136.67,93.72 136.67,94.53 136.78,94.64 137.01,94.64 137.12,94.53 137.12,93.72 137.23,93.61 137.45,93.61 137.57,93.72 137.57,94.53 137.68,94.64 137.9,94.64 138.01,94.53 138.01,93.72 138.12,93.61 138.46,93.61 138.87,94.01 138.87,94.17 138.47,94.56 138.47,94.72 138.63,94.88 138.79,94.88 139.18,94.49 139.34,94.49 139.5,94.65 139.5,94.8 139.1,95.2 139.1,95.36 139.26,95.51 139.42,95.51 139.81,95.12 139.97,95.12 140.32,95.46 141.1,95.46 141.21,95.58 141.21,95.65 141.32,95.76 141.55,95.76 141.66,95.65 141.66,95.58 141.77,95.46 141.99,95.46 142.11,95.58 142.11,95.65 142.22,95.76 142.44,95.76 142.55,95.65 142.55,95.58 142.66,95.46 142.86,95.46 142.97,95.58 142.97,96.11 143.09,96.23 143.31,96.23 143.42,96.11 143.42,95.82 144.23,95.01 144.39,95.01 144.82,95.43 144.97,95.43 145.13,95.28 145.13,95.12 144.71,94.69 144.71,94.53 145.07,94.17 146.79,94.17 147.33,93.62 151.35,93.62 151.9,94.17 153.11,94.17 155.09,96.15 155.09,102.61 155.97,103.49 156.98,103.49 157.09,103.6 v1(157.09,105.42) 157.09,105.87 157.2,105.98 157.43,105.98 157.54,105.87 157.54,103.6 157.65,103.49 157.86,103.49 158.08,103.7 v2(158.08,103.99)
  BOTTOM w0.076: UC1.AU1 133.77,93.89
  BOTTOM w0.102: v2(135.28,93.61) 135,93.89 133.77,93.89
  BOTTOM w0.112: RZ61.1 v2(158.08,103.99)
PCH_SPI_CS#2_R: length 3.5
  BOTTOM w0.112: RZ113.1 RZ61.2 158.56,106.09 158.95,106.09 159.33,106.47 UZ12.20
PCH_SPI_D0: length 40.8
  TOP w0.112: v2(152.48,100.5) 151.43,99.44 v1(150.32,99.44) RC10.2 148.42,99.44 147.39,100.47 144.49,100.47 140.74,96.72 140.17,96.72 138.3,94.86 135.32,94.86 v2(133.76,93.29) ; v2(158.19,100.24) 158.79,99.64 v2(159.41,99.64)
  BOTTOM w0.076: v2(133.76,93.29) 133.59,93.46 131.05,93.46 UC1.AV3
  BOTTOM w0.112: v2(152.48,100.5) 152.58,100.59 154.51,100.59 155.35,101.43 157.2,101.43 158.19,100.44 v2(158.19,100.24) ; v2(159.41,99.64) 159.73,99.32 161.68,99.32 RC33.1 162.83,100.39 163.31,99.91 JSPI1.17
PCH_SPI_D0_0_R: length 14.2
  TOP w0.112: v2(157.63,93.86) 157.63,93.87 RPC1.7
  BOTTOM w0.107: 157.95,91.31 157.95,91.89 157.87,91.98 155.9,91.98 155.8,92.07 155.8,92.29 155.92,92.4 v2(155.99,92.4) 157.87,92.4 157.92,92.45 157.92,92.82 157.87,92.88 156.99,92.88 156.88,92.98 156.88,93.2 156.99,93.3 157.85,93.3 157.96,93.41 157.96,93.76 157.85,93.86 v2(157.63,93.86)
  BOTTOM w0.112: 157.95,91.31 157.84,91.21 154.47,91.21 154.16,91.51 UC5.5
PCH_SPI_D0_1_R: length 13.4
  TOP w0.112: RC409.2 v2(157.63,99.45)
  BOTTOM w0.107: v2(157.63,99.45) 157.63,99.88 157.74,99.98 157.9,99.98 158.03,99.86 158.16,99.86 158.29,99.73 158.29,98.9 158.18,98.79 157.43,98.79 157.33,98.69 157.33,98.47 157.43,98.37 158.18,98.37 158.29,98.26 158.29,97.7 158.04,97.45 157.83,97.45 157.72,97.56 157.72,97.75 157.62,97.85 157.4,97.85 157.3,97.75 157.3,97.45 157.28,97.45 157.15,97.32 156.98,97.32 156.87,97.43 156.87,98.35 156.76,98.46 156.55,98.46 156.44,98.35 156.44,97.45 156.31,97.31 156.02,97.31 155.85,97.14 154.53,97.14 154.25,97.42 UC6.5
PCH_SPI_D0_2_R: length 14.5
  TOP w0.112: v2(158.83,106.58) 158.83,103.63 v1(159.5,102.96) 160.04,102.42 160.81,102.42 161.05,102.18 162.34,102.18 162.45,102.07 162.45,101.85 162.34,101.74 162.16,101.74 162.05,101.63 162.05,101.41 162.16,101.29 162.34,101.29 162.45,101.18 162.45,100.88 162.32,100.76 161.63,100.76 161.52,100.87 161.52,101.45 161.41,101.56 161.19,101.56 161.08,101.45 161.08,100.87 160.96,100.76 160.75,100.76 160.64,100.87 160.64,101.42 160.53,101.53 160.23,101.53 160.17,101.59 RZ59.2
  BOTTOM w0.112: UZ12.21 v2(158.83,106.58)
PCH_SPI_D0_R1: length 14.8
  TOP w0.112: RPC1.2 157.63,96.21 157.82,96.4 157.82,97.72 RC409.1 158.14,98.42 158.14,99.55 157.8,99.89 157.8,100.82 158.09,101.1 v1(158.9,101.1) v2(159.41,101.1) 159.42,101.09 RZ59.1
  BOTTOM w0.112: JSPI1.18 163.8,100.41 RC33.2 163.74,100.56 163.32,100.98 162.39,100.98 162.01,100.59 159.92,100.59 v2(159.41,101.1)
