# Allegro board LAE121PR10-1108.brd (continued)
## Nets (continued)
PCIE_PTX_DRX_N5: CT126.1 UC1.C19
PCIE_PTX_DRX_N6: CT124.1 UC1.D20
PCIE_PTX_DRX_N7: CT5.1 UC1.B21
PCIE_PTX_DRX_N8: CT3.1 UC1.D21
PCIE_PTX_DRX_N9: CL6.1 UC1.B23
PCIE_PTX_DRX_N11: CN69.2 UC1.D24
PCIE_PTX_DRX_N12: CN71.2 UC1.A25
PCIE_PTX_DRX_P1: CR11.1 UC1.A17
PCIE_PTX_DRX_P3: CZ12.1 UC1.C17
PCIE_PTX_DRX_P4: CZ14.1 UC1.A19
PCIE_PTX_DRX_P5: CT125.1 UC1.D19
PCIE_PTX_DRX_P6: CT123.1 UC1.C20
PCIE_PTX_DRX_P7: CT4.1 UC1.A21
PCIE_PTX_DRX_P8: CT2.1 UC1.C21
PCIE_PTX_DRX_P9: CL5.1 UC1.A23
PCIE_PTX_DRX_P11: CN70.2 UC1.C24
PCIE_PTX_DRX_P12: CN72.2 UC1.B25
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.55 JNGFF1.70 JNGFF2.46 JNGFF3.54 RE274.1 RE275.2 UT1.W1
PCIE_WAKE#_R: RE35.1 RE275.1 UE1.N13
PD1_GPIO0: RT69.1 UT5.B2
PD1_GPIO2: RT71.1 UT5.D10
PD1_GPIO5: RT74.1 UT5.E10
PD1_GPIO6: RT75.1 UT5.G10
PD1_GPIO7: RT339.1 UT5.D7
PD1_GPIO8: RT76.1 RT377.1 UT5.H6
PD#: CA31.1 DA8.2 RA18.1 RA48.2 RA50.2 UA1.47
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE1.K13
PGOOD_3V: PR107.2 PR119.1 PU100.9
PGOOD_5V: PR113.2 PR120.1 PU102.9
PLTRST_LAN#: RC62.2 UL1.36
PLTRST_TPM#: RC60.2 RC325.2 UZ12.17
PM_LANPHY_ENABLE: RL7.1 UC1.AW17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: JUSH1.4 RE324.1 UE1.E4
PORT80_DET#: RE512.1 RE513.1 RZ131.1 UE1.K4
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE1.D5
PRIM_PWRGD_GPIO024: RE361.1 RE362.1 UE1.C1
PROCHOT#_ISL88738: PQ1216.1 PR926.2 PU901.23
PS_ID: PR4.1 PR5.2 UE1.L11
PWM1_GT: PR680.1 PU602.12 PU612.8
PWM_IA: PR662.1 PU602.22 PU610.8
PWM_SA: PR606.1 PU614.3
PWM_VSA: PR606.2 PU602.30
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE1.A8
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE1.A7
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE1.A10
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE1.A9
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE1.A11
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE1.B10
RES_BIAS: RL13.1 UL1.12
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.2 UA1.17
RING2_R: CA4.1 CA13.2 DA3.3 JHP1.4 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.14
RJ45_MDIN1: JLOM1.6 TL1.20
RJ45_MDIN2: JLOM1.5 TL1.18
RJ45_MDIN3: JLOM1.8 TL1.24
RJ45_MDIP0: JLOM1.1 TL1.13
RJ45_MDIP1: JLOM1.3 TL1.19
RJ45_MDIP2: JLOM1.4 TL1.17
RJ45_MDIP3: JLOM1.7 TL1.23
RTCRST_ON: QE12.2 RE93.1 RE514.2 RE515.2
RTCRST_ON_GPIO122: RE515.1 UE1.F11
RTCRST_ON_GPIO141: RE514.1 UE1.B6
RTD3_CIO_PWR_EN: RT25.1 RT372.1 RT392.2 UC1.AC2
RTD3_CIO_PWR_EN_R: RT392.1 UT1.F1
RTD3_USB_PWR_EN: RT26.1 UT1.D4
RUN_ON: PR402.1 QE2.2 RE280.2 RE292.1 RZ320.1 RZ345.1 UE5.4 UZ3.5 UZ4.3 UZ35.2
RUN_ON#: QE2.5 QE2.6 RE68.1
RUN_ON_EC: RE292.2 RPE10.4 UE1.E8 UE5.2
RUNPWROK: QE2.3 RE67.1 UC8.1 UC8.4 UC8.10 UC8.13 UE1.G3
SA_LGATE: PQ501.8 PU614.5
SA_SNUB: PC622.1 PR627.2
SA_SW: PL614.4 PQ501.9 PR619.2 PR627.1 PU614.8
SA_UGATE: PQ501.1 PU614.1
SATA_LED_EN: QZ2.5 UE2.14
SATALED#: QZ2.4 RN100.2 RPC4.3 UC1.H1
SBIOS_TX: RE306.1 UC1.AB2
SD/MMCCD#: JSD1.9 UR1.30
SD/MMCCLK: RR5.1 UR1.17
SD/MMCCLK_R: CR21.1 JSD1.5 RR5.2
SD/MMCCMD: RR6.1 UR1.19
SD/MMCCMD_R: JSD1.3 RR6.2
SD/MMCDAT0/RCLK+: RR10.1 UR1.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR10.2
SD/MMCDAT1/RCLK-: RR9.1 UR1.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR9.2
SD/MMCDAT2: RR8.1 UR1.21
SD/MMCDAT2_R: JSD1.1 RR8.2
SD/MMCDAT3: RR7.1 UR1.20
SD/MMCDAT3_R: JSD1.2 RR7.2
SD_GPIO: RR3.2 UR1.28
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.19 UR1.25
SD_UHS2_D0P: JSD1.18 UR1.26
SD_UHS2_D1N: JSD1.21 UR1.23
SD_UHS2_D1P: JSD1.22 UR1.22
SDWP: QR1.1 UR1.29
SHD_CLK: RE374.1 UE1.J8
SHD_CLK_R1: RE374.2 UE9.6
SHD_CS#: RE98.1 RE364.1 UE1.M5 UE9.1
SHD_IO0: CE503.1 QE13.5 RE366.1 RE530.1 UE1.J7
SHD_IO0_R1: RE366.2 RE367.1
SHD_IO0_R2: RE367.2 UE9.5
SHD_IO1: RE368.1 UE1.L6
SHD_IO1_R1: RE368.2 RE369.1
SHD_IO1_R2: RE369.2 UE9.2
SHD_IO2: RE360.1 RE370.1 UE1.L7
SHD_IO2_R1: RE370.2 RE371.1 RE376.1
SHD_IO2_R2: RE371.2 UE9.3
SHD_IO3: RE372.1 UE1.M6
SHD_IO3_R1: RE372.2 RE373.1 RE377.1
SHD_IO3_R2: RE373.2 UE9.7
SIM_DET: JNGFF2.58 JSIM1.2
SIO_EXT_SCI#: RC237.1 RE341.1 UC1.AN7
SIO_EXT_SCI#_EC: RE341.2 UE1.M1
SIO_EXT_SMI#: RC346.1 RE338.1 UC1.A6
SIO_EXT_SMI#_EC: RE338.2 UE1.K7
SIO_EXT_WAKE#: RC283.1 UC1.AC1 UE1.M12
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.1 UC1.BA15 UE1.K11
SIO_RCIN#: RC13.1 RE339.1 UC1.AW13
SIO_RCIN#_EC: RE339.2 UE1.N3
SIO_SLP_A#: JAPS1.6 UC1.AN16 UE1.M11
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE1.H9 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 RZ363.1 UC1.AT11 UZ35.1
SIO_SLP_S3#: JAPS1.2 QE11.2 RE280.1 UC1.AP15 UE1.K9 UE3.2 UE5.1 UT1.D2
SIO_SLP_S4#: JAPS1.5 PR208.1 PR513.1 UC1.BA16 UE1.N12 UZ21.4 UZ34.2
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE1.N8
SIO_SLP_SUS#: PR312.2 PR406.1 PR504.1 RE349.1 RZ64.1 UC1.AN15 UZ34.1
SIO_SLP_WLAN#: RZ71.1 UC1.BB17 UE1.D9
SLEEVE: LA11.1 RA6.2 UA1.18
SLEEVE_R: CA1.2 CA12.1 DA3.2 JHP1.3 LA11.2
SLOT2_CONFIG_0: JNGFF2.13 RPE9.4 UE1.N9
SLOT2_CONFIG_1: JNGFF2.61 RPE9.3 UE1.M10
SLOT2_CONFIG_2: JNGFF2.67 RPE9.2 UE1.N10
SLOT2_CONFIG_3: JNGFF2.1 RPE9.1 UE1.F4
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: CC318.1 RC19.1 RC347.1 UC1.R9 UL1.28
SML0_SMBDATA: RC20.1 RC348.1 UC1.W2 UL1.31
SML1_SMBCLK: CC319.1 RC15.1 UC1.W3 UE1.D8
SML1_SMBDATA: RC17.1 UC1.V3 UE1.E11
SNB_+1VALWP: PC302.1 PR303.2
SNK0_CONFIG1: RT129.1 RT337.1 UT1.N4
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SNUB_CHG1: PC940.1 PR923.2
SNUB_CHG2: PC941.1 PR924.2
SPKR: RA12.2 RC183.1 UC1.AW5
SPKR_R: CA27.1 CA72.1 RA12.1 RA51.1
SRTCRST#: CC24.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.1 PU401.7
SUSACK#: UC1.AP11 UE1.K12
SUSCLK: RC48.1 RN99.2 RZ56.2 UC1.BA17
SUSCLK_R: JNGFF3.68 RN99.1
SW2_DP1_AUXN: CT175.1 RV70.1 UV7.29
SW2_DP1_AUXN_C: CT175.2 UT1.W12
SW2_DP1_AUXP: CT169.1 RV76.1 UV7.28
SW2_DP1_AUXP_C: CT169.2 UT1.Y12
SW2_DP1_CADET: RV73.1 UV7.33
SW2_DP1_HPD: RT29.1 UT1.Y6 UV7.38
SW2_DP1_N0: CT176.1 UV7.39
SW2_DP1_N0_C: CT176.2 UT1.AC15
SW2_DP1_N1: CT171.1 UV7.36
SW2_DP1_N1_C: CT171.2 UT1.AC17
SW2_DP1_N2: CT168.1 UV7.34
SW2_DP1_N2_C: CT168.2 UT1.AC19
SW2_DP1_N3: CT170.1 UV7.31
SW2_DP1_N3_C: CT170.2 UT1.AC21
SW2_DP1_P0: CT177.1 UV7.40
SW2_DP1_P0_C: CT177.2 UT1.AB15
SW2_DP1_P1: CT172.1 UV7.37
SW2_DP1_P1_C: CT172.2 UT1.AB17
SW2_DP1_P2: CT174.1 UV7.35
SW2_DP1_P2_C: CT174.2 UT1.AB19
SW2_DP1_P3: CT173.1 UV7.32
SW2_DP1_P3_C: CT173.2 UT1.AB21
SW2_DP2_AUXN: CV150.1 RV71.1 UV7.27
SW2_DP2_AUXN_C: CV150.2 JNGFF1.20
SW2_DP2_AUXP: CV149.1 RV77.1 UV7.26
SW2_DP2_AUXP_C: CV149.2 JNGFF1.22
SW2_DP2_CADET: RV74.1 UV7.43
SW2_DP2_HPD: JNGFF1.31 UV7.48
SW2_DP2_N0: CV156.1 UV7.49
SW2_DP2_N0_C: CV156.2 JNGFF1.32
SW2_DP2_N1: CV152.1 UV7.46
SW2_DP2_N1_C: CV152.2 JNGFF1.26
SW2_DP2_N2: CV148.1 UV7.44
SW2_DP2_N2_C: CV148.2 JNGFF1.25
SW2_DP2_N3: CV145.1 UV7.41
SW2_DP2_N3_C: CV145.2 JNGFF1.19
SW2_DP2_P0: CV157.1 UV7.50
SW2_DP2_P0_C: CV157.2 JNGFF1.34
SW2_DP2_P1: CV153.1 UV7.47
SW2_DP2_P1_C: CV153.2 JNGFF1.28
SW2_DP2_P2: CV147.1 UV7.45
SW2_DP2_P2_C: CV147.2 JNGFF1.27
SW2_DP2_P3: CV146.1 UV7.42
SW2_DP2_P3_C: CV146.2 JNGFF1.21
SW2_PS8338_CFG0: RV85.1 UV7.59
SW2_PS8338_P0: RV95.1 UV7.60
SW2_PS8338_P1: RV93.1 RV94.1 UV7.1
SW2_PS8338_PC10: RV90.1 RV91.1 UV7.56
SW2_PS8338_PC11: RV83.1 RV84.1 UV7.55
SW2_PS8338_PC20: RV81.1 RV82.1 UV7.54
SW2_PS8338_PC21: RV79.1 RV80.1 UV7.53
SW2_PS8338_PEQ: RV87.1 RV88.1 UV7.8
SW2_PS8338_SW: RV89.1 UV7.18
SW_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.10
SW_USB20_N1: LI7.1 UI3.11
SW_USB20_P1: LI7.4 UI3.10
SYS_LED_MASK#: QL1.2 QL1.5 QL2.2 RE21.1 UE1.A12 UZ10.1
SYS_PWROK: RC129.1 RE56.1 UC1.B6 UE1.G4
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.1 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
TBT_CIO_PLUG_EVENT#: RT371.1 RT391.1 UC1.AB12 UT1.W2
TBT_DP_RBIAS: RT35.1 UT1.N6
TBT_FORCE_PWR: RT27.1 UC1.B7 UT1.H4
TBT_I2C_SCL: RT19.1 UT1.U2 UT5.D2
TBT_I2C_SDA: RT18.1 UT1.U1 UT5.D1
TBT_JTAG_TCK: RT6.1 UT1.T4
TBT_JTAG_TDI: RT8.1 UT1.Y4
TBT_JTAG_TDO: RT5.1 UT1.W4
TBT_JTAG_TMS: RT7.1 UT1.V4
TBT_PCIE_RBIAS: RT34.1 UT1.N16
TBT_PWR_EN: T269.1(TP-1) UC1.D7
TBT_RBIAS: RT39.2 UT1.H6
TBT_RESET_N_EC: RE506.1 RT11.1 RT110.2 UT1.F4
TBT_RESET_N_EC_R: RE95.1 RE506.2 UE1.L8
TBT_ROM_CLK: UT1.AB4 UT2.6
TBT_ROM_CS#: RT2.1 UT1.AC3 UT2.1
TBT_ROM_DI: UT1.AB3 UT2.5
TBT_ROM_DO: RT3.1 UT1.AC4 UT2.2
TBT_ROM_HOLD#: RT1.1 UT2.7
TBT_ROM_WP#: RT4.1 UT1.V1 UT2.3
TBT_RSENSE: RT39.1 UT1.J6
TBT_SRC_CFG1: RT30.1 RT338.1 UT1.AA1
TBT_TMU_CLK_OUT: RT28.1 UT1.V2
TBTA_AUXN: CT81.1 UT1.W15
TBTA_AUXN_C: CT81.2 RT95.1 UT5.J2
TBTA_AUXP: CT80.1 UT1.Y15
TBTA_AUXP_C: CT80.2 RT96.1 UT5.J1
TBTA_BOT_N: RT122.2 UT5.L7
TBTA_BOT_N_R: DT20.1 JUSBC1.B7 RT122.1
TBTA_BOT_P: RT123.2 UT5.K7
TBTA_BOT_P_R: DT19.1 JUSBC1.B6 RT123.1
TBTA_CC1: CT86.1 DT7.1 JUSBC1.A5 RT104.2 UT5.L9
TBTA_CC2: CT85.1 DT16.1 JUSBC1.B5 RT105.2 UT5.L10
TBTA_DBG_CTL1: RT106.1 UT5.E4
TBTA_DBG_CTL2: RT107.1 UT5.D5
TBTA_DEBUG1: RT92.2 UT5.L2
TBTA_DEBUG2: RT93.2 UT5.K2
TBTA_DEBUG3: RT89.2 UT5.L3
TBTA_DEBUG4: RT90.2 UT5.K3
TBTA_HPD: RT23.1 RT73.1 UT1.M4
TBTA_HPD_R: RT73.2 UT5.C10
TBTA_I2C_INT: RT16.1 UT1.J4 UT5.C1
TBTA_LSRX: RT21.1 RT88.1 RT90.1 UT1.A4
TBTA_LSRX_R: RT88.2 UT5.K4
TBTA_LSTX: RT22.1 RT87.1 RT89.1 UT1.A5
TBTA_LSTX_R: RT87.2 UT5.L4
TBTA_MRESET: RT86.1 UT5.E11
TBTA_RESET_N_EC_R: RT110.1 UT5.F11
TBTA_ROM_CLK_PD: RT54.2 UT5.A3
TBTA_ROM_CLK_PD_R: JDB1.2 RT54.1 UT6.6
TBTA_ROM_CS#_PD: RT57.2 UT5.B3
TBTA_ROM_CS#_PD_R: JDB1.5 RT51.1 RT57.1 UT6.1
TBTA_ROM_DI_PD: RT55.2 UT5.B4
TBTA_ROM_DI_PD_R: JDB1.3 RT55.1 UT6.5
TBTA_ROM_DO_PD: RT56.2 UT5.A4
TBTA_ROM_DO_PD_R: JDB1.4 RT52.1 RT56.1 UT6.2
TBTA_ROM_HOLD#_PD: RT50.1 UT6.7
TBTA_ROM_WP#_PD: RT53.1 UT6.3
TBTA_ROSC: RT100.1 UT5.G2
TBTA_RX1N: DT14.1 JUSBC1.B10 UT1.A21
TBTA_RX1P: DT13.1 JUSBC1.B11 UT1.B21
TBTA_RX2N: DT9.1 JUSBC1.A10 UT1.B15
TBTA_RX2P: DT10.1 JUSBC1.A11 UT1.A15
TBTA_SBU1: DT8.1 JUSBC1.A8 RT108.2
TBTA_SBU1_R: RT108.1 UT5.K8
TBTA_SBU2: DT15.1 JUSBC1.B8 RT109.2
TBTA_SBU2_R: RT109.1 UT5.L8
TBTA_TOP_N: RT121.1 UT5.L6
TBTA_TOP_N_R: DT12.1 JUSBC1.A7 RT121.2
TBTA_TOP_P: RT120.1 UT5.K6
TBTA_TOP_P_R: DT11.1 JUSBC1.A6 RT120.2
TBTA_TX1N: CT96.1 UT1.B19
TBTA_TX1N_C: CT96.2 DT6.1 JUSBC1.A3
TBTA_TX1P: CT95.1 UT1.A19
TBTA_TX1P_C: CT95.2 DT5.1 JUSBC1.A2
TBTA_TX2N: CT98.1 UT1.B17
TBTA_TX2N_C: CT98.2 DT18.1 JUSBC1.B3
TBTA_TX2P: CT97.1 UT1.A17
TBTA_TX2P_C: CT97.2 DT17.1 JUSBC1.B2
TBTA_USB2_RBIAS: RT41.1 UT1.H19
TBTA_USB20_N: UT1.D20 UT5.K5
TBTA_USB20_P: UT1.E20 UT5.L5
TBTB_HPD: RT33.1 UT1.G2
TBTB_I2C_INT: RT17.1 UT1.E2
TBTB_LSRX: RT32.1 UT1.B5
TBTB_LSTX: RT31.1 UT1.B4
TBTB_USB2_RBIAS: RT42.1 UT1.F19
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: CC306.1 JXDP1.52 RC230.1 UC8.2
TDOCK_BATLOW#: RT20.1 UT1.F2
TEST_EN: RT36.1 UT1.E1
TEST_PWRGD: RT37.1 UT1.AB5
THERMATRIP1#: RE301.1 UE1.B12
THERMATRIP2#: CE36.1 QE4.1 RE69.2 UE1.H3
THERMDA: UT1.AB23 UT1.AC23
TOUCH_SCREEN_DET#: JEDP1.32 RV8.1 UC1.AY5
TOUCH_SCREEN_PD#: JEDP1.5 RC272.1 UC1.A7
TOUCHPAD_INTR#: JKBTP1.5 RC414.1 RE318.2 UC1.BA5
TP_LAN_JTAG_TCK: RL2.1 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.1 UL1.33
TPM_GPIO4: T283.1(TP-1) UZ12.13
TPM_LPM#: QZ9.1 RZ111.1 RZ363.2 UZ12.3
TPM_PIRQ#: RZ69.2 UC1.AP8 UZ12.18
TPM_TYPE: RC349.1 UC1.AY7
TRST#_XDP: JXDP1.54 UC8.12
TYPEC_ID: CE62.1 RE343.1 UE1.F2
UART_MISO: RT82.1 RT83.1 UT5.F2
UART_MOSI: RT81.1 RT83.2 UT5.E2
UG1_ISL88738: PQ905.1 PU901.11
UG2_ISL88738: PQ904.1 PU901.5
UIM_CLK: CZ38.1 JNGFF2.24 JSIM1.C3
UIM_DATA: CZ39.1 JNGFF2.26 JSIM1.C7 RZ335.2
UIM_RESET: CZ40.1 JNGFF2.22 JSIM1.C2
UPD1_ALERT#: RE91.1 RT60.1 UE1.F10
UPD1_SMBCLK: QT1.1 RE303.1 RT58.1 UE1.C3
UPD1_SMBCLK_Q: QT1.6 RT58.2 RT67.1 RT92.1 UT5.B5
UPD1_SMBDAT: QT1.4 RE302.1 RT59.1 UE1.B4
UPD1_SMBDAT_Q: QT1.3 RT59.2 RT66.1 RT93.1 UT5.A5
UPD1_SMBUS_ALERT#: RT60.2 RT68.1 UT5.B6
UPD2_ALERT#: RE92.1 UE1.F5
UPD2_SMBCLK: RPE12.3 UE1.D7
UPD2_SMBDAT: RPE12.4 UE1.E7
USB2_ID: RC337.1 UC1.AG3
USB2_VBUSSENSE: RC338.1 UC1.AG4
USB3_PRX_DTX_N1: DI4.1 DI4.9 JUSB1.5 UC1.H8
USB3_PRX_DTX_N2: LI16.4 RI28.1 UC1.J6
USB3_PRX_DTX_N3: DI1.1 DI1.9 JUSB2.5 UC1.J10
USB3_PRX_DTX_P1: DI4.2 DI4.8 JUSB1.6 UC1.G8
USB3_PRX_DTX_P2: LI16.1 RI27.1 UC1.H6
USB3_PRX_DTX_P3: DI1.2 DI1.8 JUSB2.6 UC1.H10
USB3_PRX_L_DTX_N2: JNGFF2.21 LI16.3 RI28.2
USB3_PRX_L_DTX_P2: JNGFF2.23 LI16.2 RI27.2
USB3_PTX_C_DRX_N1: CI13.1 DI4.4 DI4.7 JUSB1.8
USB3_PTX_C_DRX_N2: CI29.1 LI17.1 RI30.1
USB3_PTX_C_DRX_N3: CI5.1 DI1.4 DI1.7 JUSB2.8
USB3_PTX_C_DRX_P1: CI16.1 DI4.5 DI4.6 JUSB1.9
USB3_PTX_C_DRX_P2: CI30.1 LI17.4 RI29.1
USB3_PTX_C_DRX_P3: CI4.1 DI1.5 DI1.6 JUSB2.9
USB3_PTX_DRX_N1: CI13.2 UC1.C13
USB3_PTX_DRX_N2: CI29.2 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_P1: CI16.2 UC1.D13
USB3_PTX_DRX_P2: CI30.2 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_L_DRX_N2: JNGFF2.27 LI17.2 RI30.2
USB3_PTX_L_DRX_P2: JNGFF2.29 LI17.3 RI29.2
USB20_N1: UC1.AB9 UI3.2
USB20_N1_R: DI5.2 JUSB1.2 LI7.2
USB20_N2: LI3.1 UC1.AD6
USB20_N2_R: DI2.3 JUSB2.2 LI3.2
USB20_N4: LI8.1 RI48.1 UC1.AD9
USB20_N4_L: JNGFF2.9 LI8.2 RI48.2
USB20_N5: LZ1.1 UC1.AJ1
USB20_N5_R: DV8.1 JEDP1.12 LZ1.2
USB20_N7: LI9.1 RI50.1 UC1.AH1
USB20_N7_L: JNGFF1.5 LI9.2 RI50.2
USB20_N8: LV27.3 UC1.AF8
USB20_N8_R: DV4.2 JEDP1.2 LV27.4
USB20_N10: JUSH1.8 UC1.AH7
USB20_P1: UC1.AB10 UI3.3
USB20_P1_R: DI5.3 JUSB1.3 LI7.3
USB20_P2: LI3.4 UC1.AD7
USB20_P2_R: DI2.2 JUSB2.3 LI3.3
USB20_P4: LI8.4 RI47.1 UC1.AD10
USB20_P4_L: JNGFF2.7 LI8.3 RI47.2
USB20_P5: LZ1.4 UC1.AJ2
USB20_P5_R: DV7.1 JEDP1.13 LZ1.3
USB20_P7: LI9.4 RI49.1 UC1.AH2
USB20_P7_L: JNGFF1.3 LI9.3 RI49.2
USB20_P8: LV27.2 UC1.AF9
USB20_P8_R: DV4.3 JEDP1.3 LV27.1
USB20_P10: JUSH1.9 UC1.AH8
USB_OC0#: RPC3.3 UC1.A9 UI3.13
USB_OC1#: RPC3.2 UC1.C9 UI1.3
USB_OC2#: RPC3.1 UC1.D9
USB_OC3#: RPC3.4 UC1.B9
USB_PWR_EN1#: RPE11.3 UE1.K3 UI1.4
USB_PWR_EN2#: RPE11.4 UE1.G5
USB_PWR_SHR_LFT_EN#: RPE11.2 UE1.J3 UI3.6
USB_PWR_SHR_VBUS_EN: RPE11.1 UE1.J2 UI3.5
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 RE526.2 RZ87.1 UE1.C13
USH_DET#_R: DZ7.1 JUSH1.26 RZ87.2
USH_PWR_STATE#: JUSH1.22 RZ10.2 UE2.9
USH_RST#_R: JUSH1.21 RZ114.2
USH_SMBCLK: CZ62.1 JUSH1.11 RZ8.2 UE1.B3
USH_SMBDAT: CZ63.1 JUSH1.12 RZ9.2 UE1.E5
VCI_IN1#: RE507.1 UE1.B5
VCI_IN2#: RE508.1 UE1.D4
VCT_LAN_R1: RL3.1 UL1.6
VGA_ID: RE84.1 RE85.1 UE1.H11
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR604.2 PR625.1 RC152.1 RC153.2
VIDALERT_N_B: PR625.2 PU602.36
VIDSCLK: CC321.1 PR601.2 PR618.1 UC1.A63
VIDSCLK_B: PR618.2 PU602.37
VIDSOUT: PR605.2 PR626.1 RC157.1 UC1.D64
VIDSOUT_B: PR626.2 PU602.35
VRALERT#: RC73.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5105: CE38.1 RE77.1 UE1.C9
WIGIG_32KHZ: JNGFF1.50 RZ56.1
WLAN_COEX1: JNGFF1.48 RZ130.2
WLAN_COEX2: JNGFF1.46 RZ129.2
WLAN_COEX3: JNGFF1.44 RZ128.2
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56
WRST#: CE500.1 RE6.2 UE2.4
WWAN_COEX1: JNGFF2.56 RZ130.1
WWAN_COEX2: JNGFF2.54 RZ129.1
WWAN_COEX3: JNGFF2.52 RZ128.1
WWAN_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.M2
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 RE38.1 UE1.M13
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RC290.1 UC12.1
XDP_JTAGX: CC305.1 RC87.1 RC328.2 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN: CC21.1 RC46.2 UC1.E37 YC1.3
XTAL24_OUT: RC46.1 RC295.1 UC1.E35
XTAL24_OUT_R: CC22.1 RC295.2 YC1.1
XTAL_25_IN: CT21.1 UT1.D22 YT1.1
XTAL_25_OUT: RT40.1 UT1.D23
XTAL_25_OUT_R: CT20.1 RT40.2 YT1.3
XTALI: CL14.1 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.1 RL34.1 YL1.3
Z2805: RL18.1 TL1.22
Z2806: RL16.1 TL1.16
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N04748: PC939.1 PR929.1 PU901.3
N16399089: PD901.1 PD903.1 PD904.1 PR916.2
N16400770: PR901.3 PR910.1
N16404606: PD905.3 PR939.2 PR950.1
N16404788: PD905.1 PU903.1
N16775301: PC208.2 PR204.2 PR206.1 PU200.16
N16775385: PC218.1 PU200.3
N16775433: PC204.1 PR202.2
N16775513: PC205.1 PR203.2
N16775517: PR203.1 PU200.12
N16776853: PC207.1 PU200.14
N16783014: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N16783095: PC113.2 PR108.1
N16783134: PC127.2 PR117.1
N16783223: PC119.1 PU102.16 PU102.17
N16784595: PC102.1 PR100.2
N16784799: PC114.1 PR111.2
N17185092: PQ1204.6 PR1214.2 PR1218.2
N17188126: PR1211.2 PU1200.1
N17188417: PR1215.2 PU1200.2
N17263481: PR612.2 PR614.2 PU602.39
N17264741: PR616.2 PU602.40
N17335638: PC515.2 PR515.2 PR516.1 PU503.3
N17340170: PQ1205.1 PR1215.1 PR1226.2
N17370862: PC4.2 PQ4.4 PQ5.1 PR11.2 PR16.1
N17370885: PQ5.2 PR10.2 PR15.1
N17370921: PQ1.6 PR15.2
N17370927: PQ7.1 PR16.2
N17370961: PL3.1 PQ2.1 PR3.1 PR6.2
N17370983: PQ2.3 PR3.2 PR5.1
N17370995: PQ3.2 PR6.1 PR8.2
N17370999: PQ2.2 PQ3.1 PR7.2
N17371029: PC6.1 PQ9.4 PR12.2 PR18.1
N17371043: PQ6.1 PR18.2
N17371182: PQ6.2 PR23.2
N17371184: PR23.1 PU1.4
N17371196: PR21.2 PU1.1
N17371207: PQ8.1 PR22.1 PR27.1
N17372066: PQ1.3 PR17.2 PR19.2
N17372074: PQ1.5 PR25.1
N17372833: PC1206.1 PR1201.2 PR1203.1 PR1219.1 PU1201.3
N17479322: PQ1215.2 PR1251.2 PR1252.1
N17494434: PC1211.1 PD1205.1 PQ1212.1 PR1238.1 PR1239.2 PR1246.1 PR1255.2 PU1201.5
N17509431: PC947.1 PR935.1 PR947.1 PR949.2
N17509921: PD905.2 PR941.2
N17522701: PR942.2 PU903.2
N17670003: PR936.1 PR948.1 PU901.30
N17739728: PQ1205.3 PR1221.2 PR1224.1
N17747591: PQ8.3 PR26.2 PR28.1
N17747606: PQ8.2 PR29.2
N17765266: PR933.2 PR951.2 PU901.26
N17768164: PQ1210.5 PR1245.2
N17769037: PQ1207.6 PQ1211.4 PR1230.1 PR1258.2
N17769560: PQ1211.5 PR1233.1 PR1242.2
N17769738: PQ1211.2 PR1235.1 PR1257.2
N17770477: PQ1207.2 PQ1207.3 PR1232.1
N17771093: PQ1207.5 PR1241.2
N17771333: PQ1208.6 PQ1211.1 PR1234.1 PR1261.2
N17771663: PQ1208.2 PQ1208.3 PR1259.1
N17772624: PQ1208.5 PR1244.2 PR1260.2 PR1261.1
N17801240: PC1210.1 PQ1206.4 PR1228.2 PR1229.1
N17802718: PC1202.2 PQ1213.4 PQ1215.1 PR1205.2 PR1212.1
N17804163: PC1203.2 PQ1202.4 PQ1203.1 PR1207.2 PR1213.1
N17890941: PR1216.1 PU1200.4
N17892124: PQ1214.6 PR1252.2
N18264144: PQ7.2 PR20.1
N18265642: PQ1201.2 PR1216.2
N18265900: PQ1201.5 PR1220.2
N18266224: PC1213.1 PD1205.2 PR1238.2 PR1240.2 PR1243.1 PU1201.7
N18266545: PC1214.1 PQ1209.5 PR1243.2
N18267253: PQ1212.2 PR1248.1 PR1249.1 PR1250.1
N18268286: PQ1205.2 PR1225.2
N18277029: PR404.2 PR425.2 PU401.14
N18277134: PR410.2 PR426.2 PU402.14
N18278112: PR620.2 PU602.1
N18278782: PC930.1 PR914.2
N18278920: PR920.2 PU901.21
N18278998: PR922.2 PU901.22
N18287403: PQ1.2 PR19.1
N18287500: PR22.2 PU1.2
N18288083: PR946.1 PU903.4
N18288371: PQ1204.5 PR1218.1
N18288510: PQ1204.2 PR1223.1
N18290168: PR949.1 PU901.29
N18290418: PR423.1 PR424.1 PU402.5
N18325201: CL16.1 TL1.3
N18325205: CL17.1 TL1.4
N18325209: CL20.1 TL1.9
N18325213: CL21.1 TL1.10
N18364501: RV97.1 UV7.20
N18366912: CV96.1 UV7.17
N18421193: PL614.3 PR624.1
N18490882: RI14.2 UI3.16
N18762046: CA33.1 RA17.2
N18762152: CZ127.1 UZ5.10
N18762172: CZ126.1 UZ5.12
N18762349: CA51.1 RA44.1 UA1.27
N18762353: CA53.1 UA1.7
N18762355: CA52.1 UA1.39
N18762401: RA53.1 RA54.1 UA1.20
N18762411: CA29.1 UA1.35
N18762416: CA29.2 UA1.37
N18762426: CA35.1 UA1.28
N18762428: CA49.1 UA1.34
N18762438: CA25.1 UA1.19
N20151644: PR901.2 PR909.1
N20880735: PC307.2 PR308.1
N24606174: PC313.1 PU301.5
N27076067: PC944.1 PR934.2
N27077001: PR917.2 PR937.2
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.1 SW1.2
N28769860: PR421.2 PR422.1 PU401.5
N28810563: CZ110.1 UZ2.10
N28811129: CZ114.1 UZ3.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857237: T14.1(TP-1) UC1.AK13
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N28938912: CC8.1 RC29.2
N28938914: CC7.1 RC28.2
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708639: T130.1(TP-1) UC1.BB5
N31877076: JEDP1.21 LV1.1
N32590572: CZ117.1 UZ4.12
N32592963: CZ118.1 UZ4.10
N32594166: CZ109.1 UZ2.12
N32595008: RZ70.2 RZ71.2 UZ2.3
N32817808: CZ113.1 UZ3.12
N32818355: RZ64.2 RZ65.2 UZ3.3
N32819772: CZ121.1 UZ8.6
N33612393: CD31.2 RD18.1
N35551576: PQ1209.2 PQ1209.3 PR1236.1
N35551581: PQ1209.6 PR1229.2
N35551592: PC1212.1 PR1237.2 PR1247.1 PU1201.6
N35551655: PC1205.1 PR1208.2 PR1217.1 PU1201.2
N35551713: PQ1201.6 PR1212.2
N35551785: PQ1203.2 PR1202.2 PR1209.1
N35551806: PQ1204.3 PR1209.2
N35551822: PQ1201.3 PR1213.2
N36307052: RT97.2 RT98.1 RT99.1 UT5.F10
N36307117: RT85.1 UT5.G4
N36307119: RT84.1 UT5.F4
N36307669: RT63.1 UT5.F1
N36307918: RT105.1 UT5.K10
N36307920: RT104.1 UT5.K9
N36307926: RT103.1 UT5.L11
N36626863: CT90.1 RT111.2 UT7.3
N36736352: RT85.2 T220.1(TP-1)
N36736355: RT84.2 T219.1(TP-1)
N36827741: RZ120.2 UZ26.4 UZ34.4
N38312012: CT87.1 UT5.H7
N38327809: RT101.1 UT5.D6
N38749366: QV2.1 RV5.2
N38749387: QV7.1 QV8.2 RV6.1
N39468508: PC647.2 PR650.2
N39468570: PC629.2 PR639.1
N39469485: PH601.2 PR610.1 PR631.2
N39469718: PC627.1 PR632.2
N39469776: PH603.2 PR635.1 PR647.2
N39469798: PR679.1 PU614.7
N39469812: PH602.1 PR628.2
N39469818: PC631.1 PR630.2
N39469863: PC632.1 PR636.1 PU602.28
N39469888: PC627.2 PR638.2 PU602.8
N39469908: PC617.2 PR621.1
N39469972: PR678.2 PU602.38
N39469996: PC611.2 PU614.2
N39469998: PC611.1 PR619.1
N39470055: PC630.1 PR640.1 PU602.20
N39470129: PC640.1 PR646.2
N39470145: PC601.1 PR652.2
N39470169: PC630.2 PR644.1
N39470173: PC632.2 PR641.1
N39470189: PH604.1 PR642.2
N39470248: PC621.2 PR623.1
N39470250: PR621.2 PR622.2 PR623.2 PU602.5
N39470270: PH605.1 PR657.2
N39470326: PC616.2 PR617.2 PU602.4
N39470328: PC614.2 PR617.1
N39470344: PR610.2 PU602.3
N39470375: PC613.2 PR613.2 PU602.2
N39470446: PC603.1 PR602.1 PU602.34
N39470448: PC604.1 PR603.1 PU602.33
N39470528: PR608.1 PU602.32
N39470532: PR611.1 PU602.31
N39470546: PC639.2 PR645.1
N39473183: PL610.3 PR661.1
N39473185: PC671.2 PU612.7
N39473187: PR672.2 PU612.6
N39473189: PC671.1 PR672.1
N39473240: PR671.1 PU612.1
N39473270: PC655.2 PU610.7
N39473272: PR660.2 PU610.6
N39473274: PC655.1 PR660.1
N39473308: PR659.1 PU610.1
N40478997: QV4.2 RV18.2
N41228182: JNGFF2.17 RZ326.1
N41307615: CZ38.2 RZ334.1
N44311288: QE11.3 RE70.1 RE90.2
N44311298: QE4.2 RE70.2
N44321668: RE57.1 RE58.1 UE1.B1
N44321726: RE318.1 UE1.G2
N44321827: RE349.2 UE1.N4
N44321953: CE57.1 RE350.2
N44725169: CZ197.1 RZ345.2 UZ8.3
N44905504: JDIMM1.162 T50.1(TP-1)
N44907662: JDIMM1.165 T51.1(TP-1)
N45108671: JNGFF2.59 T225.1(TP-1)
N45160305: JESPI.8 RE375.1
N45555545: QZ3.1 RZ25.1
N45596940: RE13.2 RE14.1 UE2.1
N45596942: RE15.2 RE16.1 UE2.2
N45597032: RE17.2 RE18.1 UE2.3
N46307245: CZ56.1 RZ63.1
N46307369: RZ112.2 RZ362.2 UZ12.29
N46307398: RZ62.1 UZ12.27
N46307584: QZ9.2 RZ113.2
N46398396: JNGFF2.48 RZ131.2
N46398406: JNGFF2.50 RZ132.2
N46553115: QE12.1 RE94.1
N47658252: QE13.1 RE34.2 RE348.1 RE536.1 RE537.2 UE7.3
N47658256: QE13.3 QE13.6
N47658366: CE5.1 UE7.4
N119328643: PC938.1 PR930.1 PR931.2 PU901.25
N132000604: PC934.1 PR921.2
N132005053: PR917.3 PR938.2
N4771653718: PR932.1 PU901.27

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JEDP1 16 20; JHDMI1 14; JIR1 3; JKBTP1 10 17; JNGFF1 6 16 17; JNGFF2 10 12 14 16 20 33 35 36 38 39 40 41 44 45 47 51 53 55 57 60; JNGFF3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSD1 16; JSIM1 1 C4 C6 C8; JSPI1 4 21; JUSH1 2 17; PBATT1 11 12; PD2 2; PRP1 4 5; PU100 10 15; PU102 10; PU200 18 19; PU301 2; PU401 4; PU402 4; PU503 2 6 7; PU602 13; PU901 13; QL2 3 4 5; QZ7 1 2 6; RC22 2; RC405 2; RPC4 2 7; RPE12 1 2 7 8; RT69 2; RT74 2; RT75 2; RT339 2; RZ326 2; UA1 4 11 12 15 23 24 48; UC1 A3 A4 A11 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A65 A69 AB3 AB4 AB13 AB62 AC63 AD3 AD4 AE62 AE63 AF6 AF7 AF11 AF12 AF13 AF64 AF65 AF66 AF67 AF68 AF69 AF70 AF71 AG1 AG2 AG62 AG69 AG70 AH3 AH9 AH10 AH11 AH12 AH65 AH66 AH68 AH69 AH70 AH71 AJ3 AJ62 AK6 AK7 AK9 AK10 AK62 AK64 AK65 AK66 AK67 AK70 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AM5 AN1 AN2 AN3 AN21 AN22 AN25 AN27 AN43 AN45 AN46 AN48 AN50 AN52 AN53 AN55 AN56 AN60 AN61 AN65 AN66 AP1 AP2 AP3 AP4 AP13 AP21 AP22 AP25 AP27 AP30 AP33 AP37 AP40 AP43 AP45 AP46 AP48 AP50 AP52 AP53 AP55 AP56 AP60 AP61 AP65 AP66 AR21 AR22 AR25 AR27 AR30 AR32 AR33 AR37 AR38 AR40 AR56 AR60 AR61 AR65 AR66 AT5 AT21 AT22 AT25 AT27 AT30 AT32 AT33 AT37 AT38 AT40 AT60 AT61 AT65 AT66 AU5 AU21 AU22 AU25 AU27 AU30 AU33 AU37 AU40 AU56 AU58 AU60 AU61 AU63 AU65 AU66 AW1 AW20 AW42 AW44 AW46 AW48 AW68 AW69 AY1 AY2 AY20 AY21 AY42 AY43 AY44 AY46 AY47 AY48 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA7 BA8 BA9 BA42 BA43 BA44 BA46 BA47 BA48 BB2 BB4 BB7 BB9 BB11 BB42 BB44 BB46 BB48 BB57 BB66 C2 C4 C7 C8 C11 C12 C15 C16 C23 C27 C28 C29 C31 C32 C33 C36 C37 C38 C54 C70 C71 D1 D3 D4 D5 D12 D15 D16 D23 D27 D28 D29 D31 D32 D33 D36 D37 D38 D54 D71 E1 E2 E3 E10 E25 E61 F6 F10 F11 F25 F52 F60 F61 F65 G11 G61 G65 H11 H63 J1 J4 J5 J68 J71 K45 K46 L6 M1 M2 M3 M4 N1 N2 N3 N9 N11 P1 P3 P62 U6 U7 V1 V2 V62 W4 W7 W12; UD1 1; UE1 B8 B9 F7 J6; UE2 5 6 8 10 11; UE4 1; UE6 1; UI3 9 15; UR1 31; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 V18 W16 W19 Y16 Y19; UT7 4; UV7 2 4 14 58; UV24 3; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; YC1 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 713 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 5592 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 208 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 77 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 18.5
  TOP w0.112: v2(71.14,82.24) 71.78,81.61 v1(75.18,81.61) 75.21,81.61 76.54,80.27 76.54,74.62 75.84,73.92 PR210.1
  BOTTOM w0.112: RD19.1 69.2,82.86 UD1.4 70.97,82.86 71.14,82.69 v2(71.14,82.24)
1.8V_PRIM_PWRGD: length 125.1
  TOP w0.112: v2(263.65,81.16) 263.49,81.33 RE360.2 ; v2(249.33,77.05) 248.94,76.67 248.18,76.67 247.13,77.72 RE361.2
  IN2 w0.124: v2(249.33,77.05) 249.33,78.01 247.33,80.01 244.88,80.01 244.03,79.16 242,79.16 240.87,80.29 237.47,80.29 234.62,77.44 234.62,76.85 233.94,76.17 232.5,76.17 232.26,76.41 229.95,76.41 226.19,72.66 222.25,72.66 221.36,71.77 221.36,71.08 220.29,70.01 216.64,70.01 216.19,70.46 v2(216.19,70.95)
  IN3 w0.135: v2(249.33,77.05) 250.62,77.05 252.31,78.74 253.17,78.74 255.24,80.81 260.7,80.81 260.91,80.61 263.09,80.61 v2(263.65,81.16)
  BOTTOM w0.112: v2(216.19,70.95) 216.19,70.61 210.02,64.44 184.85,64.44 183.39,62.98 182.35,62.98 181.96,63.36 181.96,66.81 175.21,73.57 v1(173.63,73.57) 170.1,73.57 169.8,73.26 169.8,72.55 171.07,71.28 171.07,67.92 PR517.1 171.06,67.08 PU501.5
2.5VSP: length 1.9
  TOP w0.112: v1(147.17,64.43) 147.04,64.3 147.04,62.57
3.3V_CAM_EN#: length 154
  TOP w0.112: QZ1.2 56.2,122.9 56.65,122.44 v2(57.43,122.44) ; RC311.1 128.93,89.38 v1(127.58,90.73) 125.99,92.32 125.29,92.32 124.76,92.85 124.45,92.85 124.18,93.11 124.18,93.81 123.88,94.11 v2(123.88,94.16)
  IN2 w0.076: v2(123.88,94.16) 124.21,94.49 125.13,94.49 125.5,94.85 126.98,94.85 127.35,95.22 127.71,95.22 127.78,95.15
  IN2 w0.124: v2(57.43,122.44) 58.3,123.32 60.28,123.32 62.5,125.54 67.47,125.54 68.61,126.68 72.28,126.68 73.83,125.13 74.12,125.13 74.4,125.41 75.17,125.41 75.8,124.78 81.56,124.78 83.53,126.76 85.22,126.76 85.55,127.09 89.18,127.09 90.2,128.11 103.96,128.11 104.28,128.43 108.51,128.43 109.01,128.93 117.3,128.93 117.83,128.4 118.89,128.4 119,128.5 122.22,128.5 122.96,127.77 124.63,127.77 124.97,128.1 128.51,128.1 129.04,127.57 138.79,127.57 139.43,126.93 139.43,125.1 138.68,124.35 138.68,122.61 139.55,121.74 139.55,119.09 137.43,116.97 137.43,112.72 138.39,111.76 138.39,110.88 141.82,107.46 141.82,105.32 139.42,102.93 139.42,102.07 138.71,101.36 138.71,98.37 137.57,97.23 137.57,95.9 136.5,94.83 129.95,94.83 129.65,95.13 129.03,95.13 128.97,95.11 128.61,94.75 128.18,94.75 127.78,95.15
  BOTTOM w0.102: v2(123.88,94.16) 123.88,94.2 124.14,94.45 UC1.AT15
3.3V_TS_EN: length 169.4
  TOP w0.112: RC282.1 144.44,86.22 141.65,86.22 141.41,86.47 139.72,86.47 138.77,87.41 137.16,87.41 130.55,94.02 v1(130.55,95.03) 129.95,95.64 129.79,95.64 v2(129.39,96.05) ; QV7.2 47.89,121.01 47.31,121.58 47.31,124.7 v2(48.01,125.41)
  IN2 w0.124: v2(48.01,125.41) 49.16,124.26 53.68,124.26 56.16,121.78 59.08,121.78 62.61,125.31 67.56,125.31 68.04,125.79 70.55,125.79 70.72,125.97 72.67,125.97 73.74,124.9 74.24,124.9 74.52,125.18 75.08,125.18 75.71,124.56 81.65,124.56 83.5,126.4 85.39,126.4 85.8,126.81 89.48,126.81 90.55,127.88 104.05,127.88 104.37,128.2 109.66,128.2 109.81,128.05 118.87,128.05 119.09,128.28 122.12,128.28 122.85,127.54 124.72,127.54 125.06,127.88 128.42,127.88 128.98,127.31 138.73,127.31 139.2,126.84 139.2,125.2 138.45,124.45 138.45,122.52 139.32,121.65 139.32,119.18 137.2,117.06 137.2,112.63 138.16,111.67 138.16,110.79 141.59,107.36 141.59,105.42 139.2,103.02 139.2,102.17 138.47,101.43 138.47,98.51 137.31,97.36 137.31,96.02 136.35,95.06 130.37,95.06 v2(129.39,96.05)
  BOTTOM w0.076: v2(129.39,96.05) 129.68,95.75 UC1.AP5
3.3V_WWAN_EN: length 47.9
  TOP w0.107: UE1.C6 v2(247.88,87.46)
  TOP w0.112: UZ4.5 280.22,91.34 281.32,90.24 v1(281.32,89.41) 281.32,88.47 RZ40.2 v2(280,87.84)
  IN1 w0.119: v2(280,87.84) 279.37,87.84 274.53,83.01 268.12,83.01 267.28,83.85 267.28,85.76 v2(265.58,87.46)
  IN3 w0.135: v2(265.58,87.46) 265.58,86.79 263.7,84.91 261.06,84.91 259.66,83.51 258.14,83.51 255.4,86.26 252.32,86.26 252,86.57 252,87.12 251.27,87.86 248.22,87.86 247.88,87.52 v2(247.88,87.46)
3V5V_EN: length 71
  TOP w0.254: v2(146.84,78.57) 147.06,78.8 v2(151.88,78.8)
  IN3 w0.203: v2(184.39,58.19) 183.46,57.26 180.13,57.26 179.85,57.54 174.5,57.54 173.12,58.91 168.5,58.91 167.66,58.08 166.61,58.08 166.28,57.75 159.46,57.75 158.19,59.02 158.19,66.25 157.38,67.07 150.62,67.07 146.01,71.68 146.01,77.9 146.68,78.57 v2(146.84,78.57)
  BOTTOM w0.112: PR114.2 183.82,58.93 184.21,59.32 184.21,60.36 PD100.1 ; v2(151.88,78.8) v1(151.31,78.8)
  BOTTOM w0.254: PR114.2 183.74,58.84 v2(184.39,58.19) 184.49,58.09 PU102.12 ; PU100.12 154.01,77.78 153.44,78.34 PC128.1 152.56,78.8 PR116.1 v2(151.88,78.8)
3V_FB: length 1.9
  BOTTOM w0.254: PC113.1 154.33,78.37 154.46,78.24 PU100.13
3V_SN: length 1
  BOTTOM w0.112: PC112.1 v1(162.77,70.22)
3V_VIN:
  vias: v2(153.91,72.95) v2(154.54,72.95) v3(154.71,70.34)
5V_FB: length 3.2
  BOTTOM w0.112: PC127.1 185.68,58.93 v1(185.95,59.19)
  BOTTOM w0.254: PC127.1 184.68,58.58 184.94,58.33 PU102.13
5V_SN: length 1.3
  TOP w0.112: PC125.1 v1(190.14,57.36)
5V_VIN: length 1.4
  BOTTOM w0.102: v3(179.54,50.62) 179.67,50.62 180.5,51.46 PC115.1
+0.6V_DDR_VTT: length 84.5
  TOP w1.016: 71.4,55.19 71.4,54.37 v3(74.37,51.4) 75.4,50.37 139.25,50.37 140.54,51.65
  IN3 w1.016: 72.67,69.28 72.67,59.5 72.27,59.1 72.27,57.14
  vias: v2(70.78,56.27) v2(71.41,56.27) v2(72.16,71) v2(72.73,71) v2(142.65,52.12) v2(143.25,52.12)
+0.6VSP: length 3.5
  TOP w0.102: v1(70.57,66.81) 70.13,66.81 69.43,67.51 69.43,68.97 69.62,69.16 70,69.16
  vias: v2(70.38,70.14) v2(70.97,70.14)
+0.9V_LAN: length 7.3
  TOP w0.127: v2(242.53,129.36) 242.53,129.8 241.98,130.35 v3(241.86,130.35)
  TOP w0.203: UL1.40 244.04,126.93 v2(244.14,127.03) ; v2(248.37,124.98) 248.42,124.93 UL1.16 ; UL1.37 242.87,128.13 242,129 CL10.1 ; UL1.43 v2(244.19,125.73) ; UL1.22 v2(248.37,127.33)
  TOP w0.381: CL10.1 242.19,129.36 v2(242.53,129.36)
  vias: v2(244.14,124.34) v2(247.67,121.23) v2(248.58,121.97)
+0.9V_TBT_CIO: length 2.8
  BOTTOM w0.356: CT40.1 31.02,100.02 v2(30.99,99.99) 30.99,100.15 30.54,100.59 CT39.1
  BOTTOM w0.381: CT38.1 30.37,101.32 v2(30.34,101.29) 30.34,100.62 CT39.1
+0.9V_TBT_DP: length 2.9
  BOTTOM w0.381: v2(29.69,99.34) 29.59,99.24 CT25.1 ; CT27.1 29.08,101.33 v2(29.04,101.29) ; CT26.1 29.15,99.45 v2(29.04,99.34) 28.89,99.19 CT30.1
  vias: v1(33.68,102) v2(31.64,101.94) v2(31.64,101.29)
+0.9V_TBT_LVR_OUT: length 1
  BOTTOM w0.381: CT62.1 27.28,101.22 27.74,100.76 v2(27.74,100.64)
  vias: v1(24.36,106.31) v2(27.09,103.89) v2(27.74,103.89) v2(28.39,101.29)
+0.9V_TBT_PCIE:
  vias: v1(29.64,104.56) v2(29.04,104.54) v2(29.04,103.89) v2(29.04,103.24) v2(29.04,102.59)
+0.9V_TBT_SVR:
  vias: v2(17.61,93.71) v2(18.25,93.71) v2(18.67,92.38) v2(18.88,93.71) v2(19.31,92.38) v2(26.44,103.24) v2(26.44,102.59) v2(26.44,101.94) v2(26.44,101.29) v2(28.39,100.64) v2(29.04,100.64) v3(17.8,92.59)
+0.9V_TBT_USB: length 2.5
  BOTTOM w0.127: CT32.1 31.58,103.8 32.13,104.34 v1(32.43,104.34)
  BOTTOM w0.254: CT33.1 30.52,103.24 v2(30.99,103.24) 31.53,103.78 CT32.1
+1.0V_AMPHYPLL: length 22.6
  IN2 w0.254: v2(130.06,122.54) 130.06,122.38 129.59,121.91 129.59,117.92 128.98,117.31 127.41,117.31 127.05,116.95 127.05,111.42 126.19,110.55 125.65,110.55 125.19,110.09 125.19,108.69 v2(123.97,107.47)
  BOTTOM w0.254: UC1.L15 v2(123.97,107.47) UC1.K15 ; v2(130.06,122.54) 130.06,122.9 129.65,123.3 CC219.1 129.4,123.33 RC169.2
  vias: v3(124.6,107.69)
+1.0V_APLL: length 10.5
  IN2 w0.508: 127.71,111.19 127.71,115.15 130.1,117.54 v2(130.1,118.12)
  BOTTOM w0.127: v2(130.1,118.12) 129.81,117.83 v1(129.5,117.83)
  BOTTOM w0.254: UC1.V15 124.59,103.99 v2(124.59,104.15)
  BOTTOM w0.508: v2(130.1,118.12) 129.95,118.27 LC2.2
+1.0V_APLLEBB: length 23.1
  TOP w0.254: RC310.2 130.9,120.6 CC325.1 129.89,119.66 v1(129.37,119.13) 129.06,118.82 v2(129.06,118.12)
  TOP w0.381: CC218.1 121.43,105.03 122.01,105.61 v2(122.01,105.76)
  IN2 w0.254: v2(122.01,105.76) 122.01,105.87 122.6,106.46 122.6,106.63 123.37,107.4 123.37,107.68 124.25,108.56 124.25,109.26 124.08,109.43 124.08,112.13 124.97,113.02 124.97,117.46 125.25,117.74 128.68,117.74 v2(129.06,118.12)
  BOTTOM w0.254: v2(122.01,105.76) 122.01,105.83 122.31,106.2 UC1.N18
+1.0V_CLK1: length 8.8
  TOP w0.508: RC302.2 127.66,119.64 127.34,119.33 127.34,117.93 v2(126.45,117.04)
  BOTTOM w0.203: 124.87,114.16 124.61,113.91 124.61,113.1 124.61,113.1 UC1.A14
  BOTTOM w0.508: v2(126.45,117.04) v1(126.03,116.62) 125.25,115.83 125.25,114.54 124.87,114.16
+1.0V_CLK2: length 15.9
  TOP w0.508: v2(125.63,122.95) 125.63,122.44 v3(124.42,121.23) 123.4,120.22 123.4,117.47 122.86,116.93 122.86,111.66 122.5,111.3
  BOTTOM w0.254: v2(122.01,107.46) 121.69,107.78 UC1.K19
  BOTTOM w0.508: v2(125.63,122.95) 125.63,123.48 CC220.1 126.83,124.69 RC170.2
+1.0V_CLK3: length 15.4
  TOP w0.508: v2(126.14,119.29) 126.77,119.92 RC303.2
  IN2 w0.381: 121.28,112.15 121.28,112.81 122.68,114.21 122.68,115.1 121.84,115.94 121.84,118.68 123.01,119.85 125.58,119.85 v2(126.14,119.29)
  BOTTOM w0.127: v2(126.14,119.29) v1(126.14,118.5)
  BOTTOM w0.254: v2(120.79,107.46) 120.7,107.46 120.39,107.06 UC1.L21
+1.0V_CLK4: length 25.2
  TOP w0.127: v1(124.31,123.57) 124.17,123.43 v2(124.17,122.95)
  IN2 w0.508: v2(124.17,122.95) 124.17,121.92 121.23,118.98 121.23,114.31 119.89,112.96 119.05,112.96 118.03,111.95 118.03,111.59 117.68,111.24 117.68,109.18 118.59,108.27 118.59,107.22 120.06,105.76 120.69,105.76 v2(120.71,105.74)
  BOTTOM w0.229: UC1.N20 120.96,106.2 120.71,105.95 v2(120.71,105.74)
  BOTTOM w0.508: RC173.2 CC226.1 v2(124.17,122.95)
+1.0V_CLK5: length 20.4
  TOP w0.356: RC52.2 120.13,106.02 v1(120.77,106.66) v2(121.38,106.66)
  IN2 w0.381: 122.91,111.59 122.91,113.75 123.21,114.06 123.21,115.25 122.76,115.71 122.76,116.77 124.2,118.22 126.19,118.22 127.34,119.38 v2(127.34,122.95) ; 121.39,107.66 121.39,106.66 v2(121.38,106.66)
  BOTTOM w0.254: UC1.L19 121.67,107.04 121.39,106.67 121.39,106.66 v2(121.38,106.66)
  BOTTOM w0.508: v2(127.34,122.95) 127.34,123.48 CC221.1 127.72,123.86 RC171.2
+1.0V_CLK6: length 8.6
  BOTTOM w0.203: 127.37,114.02 127.09,113.74 UC1.A10
  BOTTOM w0.381: 127.37,114.02 128.93,115.58 128.93,117.42 v1(128.17,118.18) 127.86,118.49 CC216.1 127.88,119.31 RC300.2
+1.0V_DTS: length 19.8
  IN3 w0.381: v2(133.91,105.9) 134.64,106.64 139.25,106.64 140.46,107.85 142.27,107.85 143.05,107.07 145.02,107.07 145.85,106.25 147.75,106.25 v2(148.13,106.63)
  BOTTOM w0.076: v2(133.91,105.9) v1(134.97,105.9)
  BOTTOM w0.203: UC1.T1 132.64,105.16 133.01,105.53 133.53,105.53
  BOTTOM w0.381: 133.53,105.53 v2(133.91,105.9)
  BOTTOM w0.508: RC301.2 v2(148.13,106.63)
+1.0V_MPHYAON: length 2.6
  TOP w0.508: v2(122.66,107.46) 122.66,107.56 123.2,108.1 CC203.1
  BOTTOM w0.254: v2(122.66,107.46) UC1.K17 ; UC1.L1 132.32,107.58 v2(133.03,107.58)
  vias: v1(135.43,108.93) v2(133.63,107.58)
+1.0V_MPHYGT: length 10.5
  BOTTOM w0.254: UC1.N15 124.6,105.89 v2(124.6,105.78) 124.6,105.67 UC1.P15 ; UC1.P16 123.64,105.47 v2(123.33,105.78) 122.99,106.12 UC1.N17 ; UC1.N16 v2(123.95,106.59)
  BOTTOM w0.356: RC169.1 130.83,124.9 131.13,125.19 CC281.1
  BOTTOM w0.508: v2(131.94,124.72) RC169.1
  BOTTOM w2.032: 137.33,118.71 134.14,115.52 134.14,114.25
  vias: v1(134.36,121.98) v2(133.76,112.75) v2(133.76,112.14) v2(134.39,112.75) v2(134.39,112.14) v2(137.07,120.07) v2(137.39,120.58) v2(137.71,120.07) v2(138.02,120.58)
+1.0V_PRIM: length 41.2
  TOP w0.254: CZ105.1 118.46,126.77 117.18,125.49 114.26,125.49 114.13,125.61 105.74,125.61 v3(104.99,126.36) 104.57,126.78 104.57,132.83 103.85,133.55 RC216.1
  TOP w0.508: CC206.1 120.74,102.16 v2(121.36,101.54)
  BOTTOM w0.254: UC1.AB19 v2(121.36,101.54) UC1.AB20 ; v2(122.01,103.27) 122.34,102.94 UC1.Y18 122.34,102.66 UC1.AB17 ; v2(122.67,105.76) 122.34,105.42 UC1.P18 ; UC1.AK20 v2(121.36,98.24)
  BOTTOM w0.508: RC301.1 150.42,106.63 v2(150.94,107.15)
  vias: v2(126.45,126.8) v2(127.21,126.8) v2(127.97,126.8) v2(128.83,122.49) v2(129.42,122.5) v2(140.01,123.65) v2(140.6,123.65) v2(141.18,123.65) v2(141.77,123.65) v2(142.35,123.65) v2(142.93,123.65) v2(143.52,123.65) v2(157.73,87.72) v2(157.73,87.08) v2(158.29,88) v2(158.29,87.39) v2(158.29,86.78) v2(158.93,88) v2(158.93,87.39) v2(158.93,86.78)
+1.0V_PRIM_CORE: length 2.9
  TOP w0.457: CC205.1 121.88,100.62 v2(122.01,100.75)
  BOTTOM w0.254: UC1.AF19 121.69,100.43 v2(122.01,100.75) 122.01,100.66 UC1.AF18 ; UC1.V21 120.39,103.8 v2(120.69,104.11) 120.69,104.06 121.04,103.71 UC1.V20
  vias: v1(146.53,121.07) v2(145.2,102.98) v2(145.5,117.17) v2(146.1,117.17) v2(146.27,102.97) v2(146.71,117.17) v2(147.07,101.71) v2(147.07,101.15) v2(147.31,117.17)
+1.0V_PRIM_COREP: length 8.7
  TOP w0.254: v2(155.46,132.79) 155.46,131.27 154.86,130.67 v1(154.56,130.67) 154.32,130.67 151.33,129.14 150.14,129.14 149.97,128.98 v2(149.97,128.66)
  BOTTOM w0.254: PR423.2 v2(155.46,132.79)
  vias: v2(149.97,127.96) v2(149.97,127.38)
+1.0V_PRIM_XDP: length 29
  TOP w0.127: v2(90.61,132.22) v1(90.61,131.57)
  TOP w0.254: v2(90.61,132.22) 90.61,132.51 RC115.2 90.55,133.17 CC28.1 CC29.1 91.36,133.26 91.65,133.55 RC216.2
  BOTTOM w0.254: RC138.2 104.62,128.79 104.62,132.57 103.22,133.97 90.88,133.97 90.61,133.7 JXDP1.44 v2(90.61,132.22) 90.61,131.16 90.91,130.86 JXDP1.43
+1.0V_SRAM: length 16.1
  TOP w0.381: v2(120.72,100.7) 120.59,100.83 CC217.1
  TOP w0.762: 131.79,115.06 v1(132.27,115.54) 132.95,116.23 132.95,119.56 132.29,120.22 RC309.2
  IN3 w0.762: 131.85,113.52 131.85,113.12 131.27,112.53 128.5,112.53 126.39,110.42
  BOTTOM w0.254: UC1.AF21 v2(120.72,100.7) UC1.AF20 ; UC1.T20 v2(121.33,104.08) UC1.T19
  vias: v2(131.57,114.23) v2(132.15,114.23)
+1.0V_VCCST: length 542.3
  TOP w0.254: v2(253.41,99.22) 253.8,98.84 254.81,98.84 255.04,98.61 RE59.2 ; v2(265.86,108.49) v3(265.86,105.24) 265.86,103.34 v2(265.02,102.5) 264.67,102.86 264.67,103.62 264.2,104.09 263.5,104.09 RE90.1
  TOP w0.381: v2(92.84,124.46) 90.89,122.52 v2(90.89,122.24) ; v2(120.11,107.46) 119.9,107.46 CC202.1
  TOP w0.508: 124.93,122.95 124.93,122.76 123.79,121.61 RZ151.2 122.59,121.37 CC195.1 122.59,120.12 v2(120.44,117.97) 120.44,116.18 v2(122.13,114.49)
  IN1 w0.254: v2(161.11,56.22) 161.02,56.13 148.13,56.13 145.88,53.88 142.16,53.88 141.27,53 130.2,53 127.15,49.95 73.56,49.95 v2(72.44,51.06)
  IN1 w0.508: v2(45.35,112.7) 45.35,113.01 48.85,116.51 54.09,116.51 v2(54.33,116.27)
  IN2 w0.254: v2(120.11,107.46) 119.64,107.93 119.64,109.11 119.73,109.2 119.73,109.79 119.71,109.81 119.71,111.16 120.29,111.75 120.29,112.52 122.13,114.36 v2(122.13,114.49)
  IN2 w0.508: v2(120.44,117.97) 119.64,117.97 118.75,118.86 111.64,118.86 109.21,121.29 103.34,121.29 101.37,123.27 99.12,123.27 98.26,122.4 98.26,121.95 97.79,121.47 96.75,121.47 95.98,122.24 94.97,122.24 94.5,121.77 v2(94.5,121.36) 92.72,121.36 91.84,122.24 v2(90.89,122.24) 90.89,122.17 88.43,119.71 77.71,119.71 76.79,120.63 65.33,120.63 62.95,118.25 62.95,117.04 v2(63.21,116.79) ; v2(45.35,112.7) 45.35,112.67 45.12,112.44 45.12,108.61 43.84,107.33 43.84,103.72 44.22,103.34 44.22,96.15 44.34,96.03 44.34,94.21 44.99,93.56 v2(44.99,91.83)
  IN3 w0.254: v2(72.44,51.06) 72.44,51.83 71.91,52.36 70.99,52.36 68.78,54.57 65.33,54.57 62.28,51.52 60.88,51.52 60.17,50.81 55.45,50.81 55.24,51.01 52.76,51.01 52.45,51.32 43.31,51.32 40.66,53.96 38.68,53.96 37.03,55.61 37.03,56.99 34,60.03 34,68.08 37.79,71.87 37.79,76.62 38.38,77.21 38.38,79.96 39.39,80.97 40.47,80.97 43.29,83.79 43.29,87.95 44.99,89.65 v2(44.99,91.83) ; v2(265.86,108.49) 270.98,103.38 270.98,99.72 274.47,96.23 274.47,94.47 275.68,93.27 275.68,85.29 280.63,80.34 280.63,76.4 278.15,73.92 270.74,73.92 269.82,74.84 265.91,74.84 263.79,72.72 263.79,69.7 264.06,69.43 264.06,68.13 263.42,67.5 263.42,64.59 262.13,63.3 257.54,63.3 256.84,63.99 250.75,63.99 249.2,62.44 249.2,57.16 250.16,56.2 250.16,52.41 247.72,49.97 230.49,49.97 228.22,52.23 225.2,52.23 224.34,53.1 219.48,53.1 218.62,52.23 213.94,52.23 213.23,52.94 210.56,52.94 210.18,53.33 203.86,53.33 203.86,53.33 200.1,53.33 199.11,54.32 199.11,57.29 198.65,57.75 196.25,57.75 195.5,58.5 185.43,58.5 185.24,58.31 185.24,57.84 183.95,56.55 179.63,56.55 178.69,55.62 161.51,55.62 161.11,56.02 v2(161.11,56.22) ; v2(253.41,99.22) 252.75,99.88 252.75,102.27 254.27,103.78 263.74,103.78 v2(265.02,102.5)
  BOTTOM w0.152: UC1.A18 122.13,113.15 122.18,113.2 122.18,114.44 v2(122.13,114.49)
  BOTTOM w0.254: UC1.K20 120.82,108.09 120.54,108.09 120.39,107.94 UC1.K21 120.11,107.6 v2(120.11,107.46)
  BOTTOM w0.381: v2(94.5,121.36) 92.95,121.36 92.66,121.07 RC152.2 92.67,120.65 RC157.2 RC120.2 ; v2(94.5,121.36) RC80.2 ; v2(94.5,121.36) 94.5,121.74 94.87,122.11 96.01,122.11 96.29,121.83 RC79.2 ; RC218.2 v2(92.84,124.46) ; RC71.2 v2(90.89,122.24)
  BOTTOM w0.508: v2(63.21,116.79) 58.94,116.79 58.42,116.27 v2(54.33,116.27) ; PR605.1 PR604.1 PR601.1 PC602.1 v2(44.99,91.83)
+1.0V_VCCST_C: length 0.8
  TOP w0.127: v1(128.55,124.95) 128.52,124.98 127.74,124.98
+1.0V_VCCSTG: length 78.8
  TOP w0.254: v2(99.39,122.64) 99.08,122.34 RC130.2 ; v2(87.83,121.56) v3(86.91,120.64) 85.54,119.27 81.84,119.27 v2(80.13,117.55)
  TOP w0.508: CC199.1 117.14,108.86 RC143.2 117.24,109.78 117.67,110.22 117.67,111.29 119.64,113.27 v2(119.64,113.86) 119.29,113.86 119.02,114.12 119.02,118.45 120.74,120.17 120.74,120.91 RZ151.1
  IN2 w0.254: v2(119.64,113.86) 119.86,113.86 120.22,114.21 120.22,116.32 118.21,118.33 111.49,118.33 109.01,120.81 101.22,120.81 v2(99.39,122.64)
  BOTTOM w0.203: v2(119.64,113.86) 119.65,113.84 UC1.A22
  BOTTOM w0.254: v2(80.13,117.55) 80.13,117.41 80.48,117.05 81.2,117.05 82,117.85 RC135.2 ; v2(87.83,121.56) RC83.2 89.11,122.5 89.37,122.76 99.07,122.76 99.19,122.64 v2(99.39,122.64) ; v2(99.39,122.64) 99.02,122.27 RC81.2 98.53,122.01 98.07,121.55 RC87.2 ; v2(99.39,122.64) 99.91,122.12 RC82.2
  BOTTOM w0.305: RC131.2 79.21,120.84 79.21,119.4 79.74,118.87 RC134.2 80.13,118.52 v2(80.13,117.55)
+1.0V_VCCSTG_C: length 2.5
  TOP w0.127: 122.92,124.69 v1(120.43,124.69)
+1.0V_VCCSTG_R: length 1.4
  TOP w0.127: v2(121.07,109.54) 121.04,109.54 120.6,109.1 v1(120.6,108.88)
  BOTTOM w0.254: v2(121.07,109.54) UC1.G20
+1.0VO_DSW: length 2.3
  TOP w0.127: v2(132.87,96.78) v1(132.87,97.29)
  TOP w0.381: v2(132.87,96.78) 132.54,96.45 CC204.1
  BOTTOM w0.305: UC1.AL1 132.3,96.99 132.66,96.99 v2(132.87,96.78)
+1.0VS_VCCIO: length 240.6
  TOP w0.254: v2(209.12,71.61) 208.3,70.8 195.99,70.8 arc(186.44,72.7) 178.35,78.11 177.51,78.95 arc(171.3,88.25) 169.11,99.23 169.11,105.52 164.06,110.58 164.06,114.34 165.48,115.76 v3(165.48,116.85) 165.48,122.2 v2(166.15,122.87)
  TOP w0.381: v2(253.41,100.04) 253.99,100.61 255.59,100.61 256.6,101.62 258.15,101.62 258.92,102.39 QE11.1
  TOP w0.508: RC2.2 v2(102.75,107.96)
  IN1 w0.254: v2(138.33,126.69) 138.33,126.38 138.01,126.06 138.01,125.68 138.33,125.36 138.96,125.36 139.91,126.31 146.9,126.31 147.41,125.8 155.03,125.8 155.58,125.25 158.54,125.25 160.92,122.87 v2(166.15,122.87)
  IN2 w0.254: v2(209.12,71.61) 209.85,72.35 210.82,72.35 211.12,72.65 216,72.65 217.65,74.31 222.73,74.31 224.33,75.91 224.33,78.95 225.07,79.69 232.48,79.69 232.69,79.89 232.69,90.12 233.88,91.31 237.12,91.31 242.14,96.33 242.34,96.33 244.5,98.48 249.6,98.48 250.06,98.94 252.32,98.94 v2(253.41,100.04)
  IN3 w0.508: v2(108.27,96.66) 107.15,97.78 107.15,106.56 106.51,107.2 103.51,107.2 v2(102.75,107.96)
  BOTTOM w0.203: UC1.AL30 115.12,97.07 UC1.AM30 ; UC1.AL30 v2(115.58,98.22) ; UC1.AL30 v2(115.58,96.66) ; v2(115.58,98.22) 115.81,98.22 UC1.AK28 ; v2(115.58,98.22) 115.35,98.22 UC1.AK30
  BOTTOM w0.254: v2(108.27,96.66) UC1.AM42 v2(109.18,96.66) UC1.AL42 ; RC132.2 92.72,126.24 94.34,124.61 104.1,124.61 105.9,122.81 110.56,122.81 111,123.25 116.81,123.25 117.8,124.24 121.08,124.24 v2(121.94,125.11) ; v2(114.67,96.66) UC1.AM30 ; UC1.AM28 v2(115.58,96.66)
  vias: v2(135.15,126.69) v2(135.79,126.69) v2(136.42,126.69) v2(137.06,126.69) v2(137.69,126.69)
+1.2V_DDR_B+: length 0.7
  BOTTOM w0.112: v2(65.87,73.8) v1(65.15,73.8)
  vias: v2(65.87,75.07) v2(65.87,74.43) v2(66.51,75.32)
+1.2V_DDRP: length 22.9
  TOP w0.254: PR204.1 PC208.1 63.46,70.81 63.21,70.56 63.21,67.14 63.19,67.13 63.19,66.75 63.21,66.74 v3(63.21,63) 63.21,59.52 64.95,57.78 65.89,57.78 66.32,57.35
  TOP w0.508: v2(69.87,68.34) 70.13,68.08 PC209.1
  BOTTOM w1.016: 70.76,61.09 70.76,66.42
  vias: v2(66,58.3) v2(66.64,58.3) v2(67.27,58.3) v2(67.91,58.3) v2(68.54,58.3) v2(69.18,58.3) v2(69.94,59.83) v2(69.94,59.19) v2(69.94,58.56) v2(69.94,57.92) v2(70.57,59.83) v2(70.57,59.19) v2(70.57,58.56) v2(70.57,57.92) v2(71.21,59.83) v2(71.21,59.19) v2(71.21,58.56) v2(71.21,57.92)
+1.2V_LDO: length 0.8
  TOP w0.127: v1(275.02,60.81) 275.25,60.59 v2(275.77,60.59)
  vias: v2(271.78,61.73) v2(271.78,61.15) v2(275.41,60.11)
+1.2V_MEM: length 77.5
  TOP w0.381: v2(69.15,83.58) 70.12,84.54 77.29,84.54 83.08,78.75 83.08,77.67 84.29,76.46
  BOTTOM w0.152: UC1.BB32 114.58,90.14 v2(114.59,90.14)
  BOTTOM w0.178: UC1.BB23 119.61,91.05 119.61,89.9 v2(119.75,89.76) ; v2(105.97,90.33) UC1.BB47
  BOTTOM w0.203: UC1.BB41 109.52,90.99 v2(109.52,90.1) ; UC1.BB51 103.52,90.16 v2(103.47,90.11)
  BOTTOM w0.254: UC1.AU35 v2(111.93,94.12) ; UC1.AU23 v2(118.32,94.16) ; UC1.AU28 v2(115.58,94.15) ; UC1.AU42 v2(109.17,94.12)
  BOTTOM w0.305: v2(95.98,63.71) 95.34,63.71 94.73,63.1 JDIMM1.75 ; JDIMM1.141 111.23,62.82 111.66,63.26 v2(112.17,63.26) ; v2(111.48,55) JDIMM1.142 ; v2(83.47,63.8) 83.81,63.8 84.23,63.38 JDIMM1.33 ; JDIMM1.136 109.98,52.75 110.28,52.45 v2(110.59,52.45) ; JDIMM1.147 114.73,62.81 115.34,63.42 116.35,63.42 v2(116.37,63.39) 116.38,63.39 116.38,62.89 116.23,62.73 JDIMM1.153 ; JDIMM1.220 132.98,53.7 v2(132.98,52.46) ; JDIMM1.124 106.98,52.8 107.31,52.46 v2(107.72,52.46) 108.1,52.46 108.48,52.84 JDIMM1.130 ; JDIMM1.96 v2(99.98,55) ; JDIMM1.123 106.72,61.9 106.72,62.77 v2(107.25,63.3) ; JDIMM1.178 122.48,54.87 v2(122.35,55) ; JDIMM1.241 138.23,62.83 138.17,62.88 138.17,63.31 138.63,63.78 v2(138.79,63.78) ; JDIMM1.112 103.98,52.84 104.28,52.54 105.4,52.54 v2(105.47,52.46) 105.47,52.63 JDIMM1.118 ; JDIMM1.129 108.23,62.92 108.58,63.27 v2(108.83,63.27) 109.31,63.27 109.73,62.86 JDIMM1.135 ; JDIMM1.54 89.48,54.7 v2(89.18,55) ; JDIMM1.163 118.73,63.1 118.44,63.38 v2(118.06,63.38) 117.99,63.38 117.73,63.12 JDIMM1.159 ; JDIMM1.154 v2(116.48,55) ; JDIMM1.117 105.23,62.94 104.92,63.24 v2(104.88,63.24) 104.1,63.24 103.73,62.87 JDIMM1.111 ; v2(127.68,63.18) 127.73,63.13 JDIMM1.199 ; JDIMM1.160 117.98,53.7 v2(117.98,55) ; v2(78.98,54.94) JDIMM1.12 ; JDIMM1.148 v2(114.98,55)
  BOTTOM w0.381: UD1.5 69.17,84.16 CD32.1 v2(69.15,83.58)
  vias: v3(131.8,66.03)
+1.2V_MEM_CPUCLK: length 3.1
  TOP w0.127: v2(110.09,96.66) 109.96,96.66 v1(109.63,96.33)
  TOP w0.305: v2(110.09,96.66) 109.55,97.21 RC231.1 CC297.1
  BOTTOM w0.152: v2(110.09,96.66) 110.03,96.66 UC1.AM40
+1.8V_3.3V_ALW_VTR3: length 20.5
  TOP w0.254: RE340.2 270,81.45 265.72,81.45 264.23,82.94 v1(264.23,83.58) 264.51,83.86 264.51,87.7 264.18,88.03 PJP20.2 PJP21.2 259.34,88.03 258.53,87.22 CE21.1 258.52,87.06 UE1.N5
+1.8V_PGPPF: length 7.7
  TOP w0.381: v2(123.9,100.75) 123.9,100.86 124.26,101.22 124.82,101.22 124.86,101.19 v1(126.26,101.19) 126.31,101.19 126.34,101.16 130.5,101.16 RC304.2
  BOTTOM w0.254: UC1.AF16 123.89,100.59 123.89,100.68 123.87,100.7 123.87,100.72 v2(123.9,100.75)
+1.8V_PRIM: length 239.9
  TOP w0.381: RC304.1 131.56,101.05 CC212.1 132.42,101.76 v2(133.07,102.41) 133.07,102.23 133.46,101.84 135.63,101.84 135.88,101.59 139.62,101.59 v2(139.68,101.65) 139.7,101.64 139.7,100.87 RC234.1
  TOP w0.508: v2(154.96,88.29) 154.66,88.59 153.98,88.59 151.91,86.53 151.91,85.04 v3(150.06,83.2) 148.41,81.54 RC212.1 147.74,80.97 145.97,79.21 145.97,75.7 149.96,71.72 159.8,71.72 v2(160.23,72.15)
  IN1 w0.508: v2(155.5,92.76) 155.15,92.42 155.15,88.72 154.96,88.53 v2(154.96,88.29) ; v2(267.31,78.88) 266.83,79.36 266.83,85.38 265.07,87.13 v2(263.59,87.13)
  IN2 w0.508: v2(211.17,50.48) 211.8,49.86 245.83,49.86 v2(247.51,51.53)
  IN3 w0.508: v2(247.51,51.53) 247.51,53.59 248.23,54.31 248.23,56.35 246.85,57.73 246.85,60.27 247.29,60.72 247.29,61.72 251.39,65.83 259.84,65.83 260.26,65.41 261.26,65.41 262.17,66.32 262.17,68.29 261.02,69.44 261.02,71.9 267.31,78.19 v2(267.31,78.88) ; v2(139.68,101.65) 139.68,103.25 142.93,106.5 144.79,106.5 145.61,105.67 147.93,105.67 150.45,103.16 152.71,103.16 155,100.86 155,96.28 155.5,95.78 v2(155.5,92.76) ; v2(160.23,72.15) 162.46,72.15 162.99,72.68 169.9,72.68 v2(170.25,73.04)
  BOTTOM w0.203: v2(133.07,102.41) 133.04,102.41 132.97,102.49 132.11,102.49 UC1.AA1
  BOTTOM w0.508: v2(139.68,101.65) 139.53,101.8 RC313.1 ; v2(211.17,50.48) 207.16,50.48 206.03,51.61 ; v2(170.25,73.04) 170.89,72.4 171.14,72.4 173.81,69.73 176.5,69.73 180.75,65.49 180.75,61.54
  BOTTOM w0.762: 179.67,60.46 180.75,61.54 181.84,61.54 182.12,61.82 183.92,61.82 185.1,63 200.76,63 201.87,61.9 201.87,58.56 204.16,56.26 204.16,52.35 204.53,51.98
  vias: v2(205.68,52.72) v2(205.68,52.12)
