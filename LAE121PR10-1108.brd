# Allegro board LAE121PR10-1108.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+0.9V_TBT_CIO on TOP (solid shape): 30.96,101.5 30.96,100.34 31.12,100.18 31.15,100.15 31.22,100.09 31.22,99.87 31.16,99.84 31.13,99.8 31.1,99.76 31.08,99.69 31.06,99.67 30.89,99.66 30.76,99.57 30.71,99.53 30.61,99.53 30.53,99.61 30.53,99.66 30.55,99.72 30.59,99.78 30.67,99.99 30.59,100.2 30.56,100.24 30.14,100.66 30.14,100.77 30.24,100.96 30.14,101.15 30.1,101.19 30.1,101.38 30.14,101.42 30.19,101.47 30.24,101.59 30.38,101.73 30.72,101.73
+0.9V_TBT_DP on TOP (solid shape): 29.78,99.68 29.78,99.66 29.82,99.53 29.93,99.45 29.95,99.44 29.95,99.26 29.85,99.17 29.83,99.15 29.51,98.83 29.36,98.83 29.17,99.02 28.9,99.02 28.75,98.87 28.66,98.87 28.62,98.92 28.58,98.95 28.35,99.18 28.35,99.51 28.61,99.77 29.69,99.77
+0.9V_TBT_DP on TOP (solid shape): 32.03,102.37 32.07,102.34 32.1,102.31 32.1,102.21 32.04,102.15 31.96,102.07 31.96,101.94 31.96,101.82 32.07,101.68 31.98,101.59 31.85,101.3 31.97,100.99 31.98,100.96 31.97,100.93 31.94,100.9 31.91,100.88 31.87,100.89 31.59,100.98 31.35,100.81 31.34,100.79 31.22,100.79 31.09,100.91 31.09,101.73 31.41,102.05 31.41,102.06 31.47,102.1 31.52,102.16 31.52,102.17 31.56,102.2 31.72,102.2 31.89,102.37
+0.9V_TBT_DP on BOTTOM (solid shape): 33.95,103.02 33.95,101 33.86,100.91 33.37,100.91 33.3,100.99 33.3,101.46 33.09,101.66 32.05,101.66 31.9,101.51 31.9,101.18 31.77,101.05 31.42,101.05 31.29,101.18 31.29,102.07 31.52,102.3 31.9,102.3 32.05,102.45 32.05,102.88 33.17,102.88 33.4,103.11 33.86,103.11
+0.9V_TBT_DP on IN1 (solid shape): outline of 450 points within 27.85,98.44 31.97,103
+0.9V_TBT_LVR_OUT on TOP (solid shape): 27.87,101.48 28.06,101.38 28.25,101.48 28.48,101.48 28.61,101.36 28.61,101.17 28.55,101.12 28.5,101.06 28.41,100.97 28.39,100.97 28.25,100.94 28.01,100.73 28.01,100.59 27.85,100.42 27.67,100.42 27.49,100.6 27.49,100.76 27.28,100.98 27.28,101.23 27.43,101.38 27.49,101.4 27.55,101.43 27.6,101.48
+0.9V_TBT_LVR_OUT on BOTTOM (solid shape): 24.85,107.45 24.97,107.34 24.97,105.07 25.45,104.58 25.98,104.58 26.12,104.45 26.12,104.44 26.31,104.23 26.6,104.25 26.61,104.25 27.7,104.25 27.96,103.98 27.96,103.72 27.9,103.66 27.33,103.66 27.24,103.67 27.15,103.66 26.07,103.66 26.03,103.62 25.54,103.62 25.5,103.66 25.5,104.01 25.46,104.05 25.46,104.13 25.42,104.13 25.31,104.24 24.6,104.24 24.15,104.68 24.15,106.82 23.46,107.52 23.46,108.15 24.85,108.15
+0.9V_TBT_LVR_OUT on IN1 (solid shape): 27.99,104.02 27.99,103.34 27.52,102.87 27.49,102.84 27.43,102.78 27.42,102.76 27.38,102.58 27.43,102.4 27.43,102.12 27.39,101.84 27.57,101.62 27.58,101.62 27.63,101.56 28.47,101.56 28.6,101.43 28.6,101.1 28.5,101 28.14,101 27.99,100.85 27.99,100.49 27.96,100.47 27.94,100.47 27.87,100.39 27.63,100.39 27.52,100.51 27.52,100.84 27.51,100.85 27.51,100.9 27.35,101.05 26.95,101.05 26.8,101.2 26.8,104.02 26.97,104.2 27.81,104.2
+0.9V_TBT_PCIE on TOP (solid shape): 30.1,104.95 30.14,104.92 30.14,104.15 30.08,104.09 29.56,103.58 29.56,102.89 29.54,102.88 29.36,102.59 29.52,102.3 29.53,102.24 29.5,102.18 29.44,102.12 29.04,102.12 28.97,102.15 28.94,102.22 28.93,102.34 28.87,102.43 28.87,102.74 28.94,102.91 28.87,103.08 28.87,103.13 28.8,103.2 28.77,103.28 28.81,103.36 28.93,103.5 28.91,103.68 28.85,103.74 28.78,103.78 28.71,103.85 28.7,104 28.61,104.13 28.61,104.29 28.72,104.54 28.61,104.78 28.61,104.94 28.65,104.98 28.75,104.98 28.81,104.92 28.88,104.87 28.97,104.78 29.11,104.78 29.27,104.62 29.46,104.62 29.6,104.77 29.73,104.77 29.76,104.77 29.99,105 30.06,105
+0.9V_TBT_PCIE on BOTTOM (solid shape): 30.27,107.03 30.27,105.58 30.15,105.46 30.1,105.42 29.97,105.28 29.97,104.09 29.37,103.49 29.37,102.69 29.36,102.6 29.36,102.52 29.37,102.49 29.23,102.36 28.86,102.36 28.76,102.46 28.76,104.63 28.94,104.81 29.25,104.81 29.44,105 29.44,105.38 29.25,105.57 28.82,105.57 28.76,105.63 28.76,107.06 28.77,107.07 30.23,107.07
+0.9V_TBT_SVR on TOP (solid shape): 21.3,91.13 18.88,91.13 18.63,91.39 16.6,91.39 16.15,91.83 16.15,93.61 16.47,93.93 19.58,93.93 19.84,94.18 19.84,94.82 21.3,94.82
+0.9V_TBT_SVR on TOP (solid shape): 28.59,100.75 28.63,100.68 28.76,100.68 28.93,100.86 29.15,100.86 29.26,100.76 29.39,100.73 29.42,100.74 29.5,100.66 29.5,100.21 29.44,100.15 28.03,100.15 27.94,100.25 27.94,100.35 28.12,100.53 28.12,100.68 28.27,100.83 28.33,100.86 28.39,100.86 28.45,100.86 28.47,100.87
+0.9V_TBT_SVR on TOP (solid shape): 26.57,103.43 26.65,103.36 26.75,103.33 26.76,103.33 26.96,103.13 26.96,100.98 26.88,100.89 26.83,100.85 26.69,100.85 26.56,100.94 26.4,100.96 26.37,100.96 26.34,100.99 26.33,101.04 26.31,101.07 26.24,101.15 26.13,101.19 26.11,101.19 25.94,101.36 25.94,101.65 26.12,101.91 25.99,102.2 25.99,102.31 26.05,102.36 26.09,102.43 26.13,102.47 26.13,102.59 26.35,102.81 26.35,103.02 26.21,103.16 26.21,103.35 26.26,103.38 26.31,103.45 26.56,103.45
+0.9V_TBT_SVR on BOTTOM (solid shape): outline of 222 points within 17.23,92.15 27.39,103.46
+0.9V_TBT_SVR on IN2 (solid shape): outline of 347 points within 24.94,99.71 29.27,104.35
+1.0V_AMPHYPLL on TOP (solid shape): outline of 218 points within 123.75,107.25 125.82,111.39
+1.0V_APLL on TOP (solid shape): 124.74,104.66 124.93,104.47 125.25,104.47 125.44,104.28 125.44,103.2 124.93,103.2 124.93,103.58 124.61,103.9 124.48,103.9 124.36,104.02 124.36,104.91 124.74,104.91
+1.0V_APLL on IN2 (solid shape): outline of 586 points within 124.23,103.9 128.07,111.64
+1.0V_CLK2 on TOP (solid shape): 123.01,111.76 123.01,111.37 122.82,111.18 122.75,111.14 122.69,111.07 122.57,110.83 122.67,110.57 122.7,110.5 122.67,110.42 122.57,110.17 122.69,109.92 122.73,109.86 122.71,109.79 122.65,109.57 122.75,109.36 122.75,109.28 122.67,109.19 122.63,109.08 122.58,108.81 122.75,108.6 122.75,108.24 122.26,107.75 122.26,107.34 122.11,107.19 121.78,107.19 121.67,107.29 121.67,108.1 122.23,108.66 122.34,108.91 122.23,109.16 122.2,109.23 122.23,109.3 122.31,109.54 122.19,109.77 122.16,109.85 122.19,109.93 122.31,110.17 122.21,110.42 122.17,110.5 122.21,110.57 122.31,110.85 122.14,111.1 122.12,111.12 122.12,111.33 122.64,111.85 122.92,111.85
+1.0V_CLK3 on IN2 (solid shape): outline of 234 points within 120.39,107.22 121.66,112.3
+1.0V_CLK5 on IN2 (solid shape): outline of 218 points within 121.18,106.44 123.65,112.33
+1.0V_MPHYAON on TOP (solid shape): 141.5,119.96 141.5,118.06 137.06,113.61 137.06,109.78 134.35,107.07 132.93,107.07 132.74,107.26 132.74,108.02 132.93,108.21 134.14,108.21 134.58,108.66 134.59,108.66 134.73,108.74 134.81,108.88 134.81,108.89 135.66,109.74 135.66,110.59 135.7,110.6 135.77,110.62 135.84,110.67 135.9,110.69 135.96,110.67 136.55,110.94 135.96,111.21 135.9,111.19 135.84,111.21 135.77,111.26 135.7,111.28 135.66,111.29 135.66,114.63 140.11,119.07 140.11,119.96 140.3,120.15 141.31,120.15
+1.0V_MPHYAON on IN3 (solid shape): outline of 510 points within 122.4,106.03 133.86,107.84
+1.0V_MPHYGT on TOP (solid shape): 123.49,106.21 124.13,106.21 124.25,106.09 124.25,105.48 124.06,105.29 123.66,105.29 123.52,105.16 123.52,104.61 123.45,104.53 122.87,104.53 122.78,104.62 122.78,105.37 123.03,105.62 123.03,105.81 123.03,105.82 123.03,105.96 123.28,106.21 123.48,106.21
+1.0V_MPHYGT on TOP (solid shape): outline of 146 points within 130.58,119.64 138.58,125.09
+1.0V_MPHYGT on BOTTOM (solid shape): 135.15,112.53 134.52,111.9 133.63,111.9 133.5,112.02 133.5,112.79 133.12,113.17 133.12,114.69 133.18,114.76 135.15,114.76
+1.0V_MPHYGT on BOTTOM (solid shape): 138.01,121.86 138.71,121.86 138.71,122.38 139.21,122.38 139.21,121.86 139.91,121.86 139.91,122.38 140.87,122.38 141.18,122.06 141.18,118.88 141.06,118.76 138.84,118.76 138.14,118.06 136.99,118.06 136.87,118.18 136.87,120.28 137.12,120.53 137.12,122.18 137.31,122.38 138.01,122.38
+1.0V_MPHYGT on IN1 (solid shape): outline of 1291 points within 122.69,105.17 136.36,112.98
+1.0V_PRIM on TOP (solid shape): 143.72,123.77 143.72,123.2 143.28,122.76 141.95,122.76 141.5,122.31 141.5,121.04 141.38,120.91 140.23,120.91 140.11,121.04 140.11,122.69 139.75,123.05 139.75,123.73 139.91,123.88 143.62,123.88
+1.0V_PRIM on TOP (solid shape): outline of 147 points within 120.32,121.19 130.45,128.76
+1.0V_PRIM on BOTTOM (solid shape): 129.67,122.62 129.67,121 130.33,120.34 130.33,119.84 129.44,119.84 129.31,119.96 127.47,119.96 127.47,121.36 128.36,121.36 128.55,121.55 128.55,122.57 128.68,122.69 129.59,122.69
+1.0V_PRIM on BOTTOM (solid shape): 160.04,88.81 159.53,88.81 159.53,88.11 160.04,88.11 160.04,87.61 159.53,87.61 159.53,86.91 160.04,86.91 160.04,86.37 157.73,86.37 157.48,86.62 157.48,89.11 157.72,89.36 160.04,89.36
+1.0V_PRIM on BOTTOM (solid shape): 134.25,125.96 135.57,125.96 136.3,125.23 143.36,125.23 143.84,124.76 143.84,122.95 143.4,122.51 139.81,122.51 139.81,122.5 139.79,122.5 139.79,121.99 139.34,121.99 139.34,122.5 139.31,122.5 139.31,122.51 138.61,122.51 138.61,122.5 138.59,122.5 138.59,121.99 138.14,121.99 138.14,122.5 138.11,122.5 138.11,122.51 136.92,122.51 136.53,122.9 135.68,122.9 134.67,123.91 133.7,123.91 132.88,124.73 132.78,125.03 132.48,125.13 131.42,126.19 128.68,126.19 128,125.51 123.87,125.51 123.85,125.54 123.85,126.02 124,126.17 125.35,126.17 126.96,127.78 132.42,127.78
+1.0V_PRIM on IN2 (solid shape): outline of 269 points within 119.91,97.17 123.47,103.58
+1.0V_PRIM on VCC: 151.34,86.5 151.34,92.45 150.65,93.14 150.65,117.46 149.48,118.63 141.84,118.63 133.12,109.91 133.12,108.68 133.95,107.86 133.95,95.81 132.87,94.73 132.87,93.29 121.12,93.29 121.12,101.66 121.69,102.23 121.69,103.25 122.39,103.94 122.39,105.85 124.93,108.39 124.93,117.76 126.18,119.01 132.15,119.01 137.23,124.09 156.87,124.09 156.87,93.5 161.31,89.06 161.31,86.86 160.95,86.5
+1.0V_PRIM_CORE on BOTTOM (solid shape): 150.45,125.23 150.45,123.92 147.6,121.07 147.6,117.1 147.41,116.91 145.44,116.91 144.93,117.42 144.93,123.28 147.02,125.37 148.58,125.37 148.58,124.81 149.12,124.81 149.12,125.37 149.37,125.37 149.37,124.82 149.92,124.82 149.92,125.37 150.31,125.37
+1.0V_PRIM_CORE on IN1 (solid shape): outline of 1497 points within 120.1,98.82 147.35,105.4
+1.0V_PRIM_CORE on IN2 (solid shape): outline of 346 points within 144.96,100.91 148.39,117.55
+1.0V_PRIM_COREP on TOP (solid shape): 150.96,128.73 150.96,127.01 149.88,127.01 149.76,127.14 149.76,128.79 149.86,128.89 150.8,128.89
+1.0V_PRIM_COREP on BOTTOM (solid shape): 152.3,129.17 152.3,126.73 152.65,126.38 154.91,126.38 155.51,126.97 155.51,127.58 155.6,127.67 156.34,127.67 156.41,127.6 156.41,127.14 156.28,127.01 156.28,126.63 155.33,125.68 151.46,125.68 151.31,125.52 149.78,125.52 149.78,124.97 149.53,124.97 149.53,125.52 148.97,125.52 148.97,124.97 148.72,124.97 148.72,125.52 148.25,125.52 148.19,125.58 148.19,126.72 148.28,126.82 149.63,126.82 149.76,126.95 149.76,129.04 149.95,129.23 152.23,129.23
+1.0V_SRAM on TOP (solid shape): 132.17,114.56 132.36,114.37 132.36,114.12 132.23,113.99 131.47,113.99 131.34,114.12 131.34,114.44 131.41,114.5 131.41,115.26 132.17,115.26
+1.0V_SRAM on IN3 (solid shape): 132.38,114.34 132.38,113.12 132.08,112.81 131.37,112.81 131.37,113.17 131.47,113.27 131.47,114.01 131.37,114.11 131.37,114.34 131.49,114.46 132.26,114.46
+1.0V_SRAM on IN3 (solid shape): outline of 759 points within 119.18,100.57 127.25,111.77
+1.0V_VCCST on TOP (solid shape): 125.97,124.52 125.97,123.57 125.9,123.51 125.3,123.51 125.18,123.39 125.18,122.82 124.67,122.82 124.67,124.09 125.12,124.53 125.95,124.53
+1.0V_VCCST_C on TOP (solid shape): 128.27,125.92 128.27,125.68 128.14,125.55 128.14,124.06 127.76,124.06 127.69,123.99 127.67,123.99 127.67,123.98 127.23,123.53 126.69,123.53 126.69,125.92 126.82,126.05 128.14,126.05
+1.0V_VCCSTG on TOP (solid shape): 122.13,124.18 122.12,124.17 121.89,124.17 121.89,123.66 122.45,123.66 122.45,123.38 122.12,123.38 121.75,123.01 121.75,121.17 121.18,121.17 121.12,121.23 121.12,124.22 121.3,124.39 122.13,124.39
+1.0V_VCCSTG_C on TOP (solid shape): 123.9,125.89 123.9,123.63 123.67,123.4 122.63,123.4 122.63,125.36 122.3,125.69 122.3,125.89 122.45,126.05 123.75,126.05
+1.0V_VCCSTG_R on TOP (solid shape): 120.85,111.26 120.85,111.21 120.84,111.2 120.74,110.95 120.85,110.71 120.85,110.43 120.74,110.18 120.85,109.93 120.86,109.92 120.86,109.9 121,109.76 121.18,109.76 121.31,109.64 121.31,109.46 121.18,109.33 120.62,109.33 120.53,109.43 120.54,109.46 120.55,109.65 120.45,109.82 120.45,110.06 120.5,110.25 120.45,110.43 120.45,110.65 120.45,110.67 120.5,110.83 120.45,110.99 120.4,111.06 120.35,111.1 120.24,111.21 119.33,111.21 119.32,111.22 118.89,111.12 118.95,110.68 118.95,110.32 118.94,110.31 118.91,110.18 118.94,110.04 118.95,110.03 118.95,108.29 118.34,108.29 118.34,109.15 118.38,109.15 118.52,109.3 118.63,109.55 118.52,109.8 118.52,111.26 118.77,111.52 120.6,111.52
+1.0VS_VCCIO on TOP (solid shape): 109.37,96.85 109.37,96.59 109.24,96.47 108.04,96.47 107.85,96.28 107.85,96.02 107.28,96.02 107.09,96.21 107.09,97.55 108.67,97.55
+1.0VS_VCCIO on TOP (solid shape): 116.05,99.1 116.05,98.03 116.23,97.85 116.86,97.85 116.94,97.93 117.04,97.93 117.4,97.57 116.9,97.08 116.27,97.08 115.63,96.44 114.49,96.44 114.39,96.54 114.39,97.45 115.03,98.09 115.03,98.41 114.85,98.6 114.59,98.6 114.55,98.63 114.55,99.13 114.6,99.18 115.96,99.18
+1.0VS_VCCIO on BOTTOM (solid shape): 136.57,127.29 137.12,127.29 137.12,127.33 137.12,127.84 137.37,127.84 137.37,127.33 137.38,127.33 137.38,127.3 137.92,127.3 137.92,127.4 137.92,127.4 137.92,127.84 138.45,127.84 138.64,127.65 138.64,126.71 138.4,126.47 134.94,126.47 134.83,126.57 134.83,127.65 135.03,127.84 136.57,127.84
+1.0VS_VCCIO on IN1 (solid shape): outline of 365 points within 107.92,96.36 116.09,99.03
+1.0VS_VCCIO on VCC: 106.45,93.29 106.45,97.55 114.28,97.55 115.17,98.44 118.15,98.44 118.52,98.8 118.52,105.85 118.83,106.17 118.83,112.71 119.85,113.72 119.85,118.74 121.5,120.39 121.5,127.2 122.39,128.09 138.03,128.09 138.71,127.41 138.71,124.6 137.02,124.6 131.94,119.52 125.97,119.52 124.48,118.04 124.48,117.83 124.55,117.76 124.55,108.55 122.01,106.01 122.01,104.1 121.51,103.61 121.04,103.36 121.31,102.9 121.31,102.39 120.74,101.82 120.74,93.29
+1.2V_DDR_B+ on TOP (solid shape): 67.4,76.08 67.4,75.13 67.14,74.88 67.14,73.42 67.08,73.35 64.6,73.35 63.93,74.02 63.93,74.54 64.36,74.54 64.36,75.05 63.93,75.05 63.93,75.34 64.36,75.34 64.36,75.85 63.93,75.85 63.93,76.21 67.27,76.21
+1.2V_DDR_B+ on BOTTOM (solid shape): 67.33,75.51 67.33,75.13 67.21,75 67.21,73.16 67.33,73.04 67.33,70.66 67.32,70.65 67.32,70.52 66.92,70.52 66.92,72.19 66.76,72.34 65.81,72.34 65.56,72.59 65.56,75.26 65.94,75.64 67.21,75.64
+1.2V_DDRP on TOP (solid shape): 72.03,60.88 72.03,60.06 72.03,60.06 72.03,59.28 72.1,59.28 72.13,59.26 72.54,59.26 72.54,58.81 72.03,58.81 72.03,58.78 72.03,58.78 72.03,58.08 72.03,58.08 72.03,58.06 72.54,58.06 72.54,57.61 72.03,57.61 72.03,57.58 72.03,57.58 72.03,56.93 71.94,56.84 69.62,56.84 69.37,57.1 65.94,57.1 65.75,57.29 65.75,60.78 66.06,61.1 71.82,61.1
+1.2V_DDRP on BOTTOM (solid shape): 71.27,57.16 70.89,56.78 69.7,56.78 69.39,57.08 65.76,57.08 65.43,57.41 65.43,60.97 65.66,61.2 69.98,61.2 70.26,61.48 71.27,61.48
+1.2V_DDRP on BOTTOM (solid shape): 69.73,69.19 70.67,69.19 70.89,68.97 70.89,68.32 71.26,67.96 71.26,66.69 71.27,66.67 71.27,66.11 70.26,66.11 70.26,67.51 69.02,68.74 68.82,68.74 68.77,68.79 68.77,69.35 68.85,69.43 69.49,69.43
+1.2V_LDO on TOP (solid shape): 274.39,63.21 274.39,62.11 274.19,61.91 274.19,61.2 273.91,60.92 271.63,60.92 271.5,61.05 271.5,61.81 271.71,62.02 273.84,62.02 274.15,62.34 274.15,63.21 274.23,63.28 274.31,63.28
+1.2V_LDO on TOP (solid shape): 275.97,63.21 275.97,62.44 276.2,62.22 276.3,62.22 276.43,62.09 276.43,60.08 276.2,59.85 275.33,59.85 275.16,60.03 275.16,60.54 275.46,60.84 275.64,60.84 275.87,60.84 276.02,60.99 276.02,61.22 276.02,62.06 275.77,62.32 275.77,63.21 275.82,63.26 275.92,63.26
+1.2V_LDO on IN1 (solid shape): 274.61,61.43 274.6,61.41 274.74,60.98 275.18,60.85 275.24,60.87 275.31,60.87 275.33,60.85 275.63,60.72 275.96,60.81 275.99,60.84 276.22,60.61 276.22,60.43 275.37,59.58 274.77,59.58 273.8,60.56 271.98,60.56 271.37,61.17 271.37,61.92 271.54,62.09 273.95,62.09
+1.2V_MEM on TOP (solid shape): 91.04,65.76 83.04,65.76 83.04,73.76 91.04,73.76
+1.2V_MEM on TOP (solid shape): 108.92,65.32 98.92,65.32 98.92,80.32 108.92,80.32
+1.2V_MEM on TOP (solid shape): 118.83,66.48 110.83,66.48 110.83,74.48 118.83,74.48
+1.2V_MEM on TOP (solid shape): outline of 11167 points within 72.15,51.62 139.03,97.74
+1.8V_PRIM on TOP (solid shape): 206.78,52.46 206.78,51.83 206.72,51.76 205.57,51.76 205.57,51.77 205.55,51.77 205.31,52.01 205.31,52.96 205.42,53.07 206.17,53.07
+1.8V_PRIM on TOP (solid shape): 262.15,87.25 262.59,87.25 262.59,87.78 263.89,87.78 264.13,87.54 264.13,86.5 264.01,86.37 261.72,86.37 261.48,86.61 261.48,87.69 261.57,87.78 262.15,87.78
+1.8V_PRIM on BOTTOM (solid shape): 178.94,60.87 180.03,60.87 180.05,60.86 180.05,60.27 179.86,60.08 178.33,60.08 177.89,60.53 177.89,60.59 178.52,61.22 178.59,61.22
+1.8V_PRIM on BOTTOM (solid shape): 206.35,52.52 206.35,51.72 206,51.37 204.46,51.37 204.17,51.66 204.17,52.32 204.32,52.47 205.01,52.47 205.52,52.98 205.9,52.98
+1.8V_RUN on TOP (solid shape): 214.4,51.7 214.4,51.17 214.17,50.94 212.5,50.94 212.43,51 212.43,51.95 214.15,51.95
+1.8V_RUN_AUDIO on TOP (solid shape): 263.61,57.4 263.61,55.22 263.64,55.2 263.64,54.49 263.54,54.39 262.85,54.39 262.73,54.52 262.73,56.41 262.53,56.6 261.42,56.6 261.34,56.68 261.34,57.14 261.42,57.21 262.76,57.21 262.96,57.41 263.6,57.41
+1.8V_RUN_CARD on TOP (solid shape): 298.5,59.14 299.46,59.14 299.53,59.08 299.53,58.6 299.46,58.53 297.41,58.53 297.41,59.47 297.46,59.52 298.12,59.52
+1.8V_RUN_CARD on TOP (solid shape): 283.45,63.68 283.45,62.61 283.01,62.16 282.01,62.16 281.43,62.75 280.57,62.75 280.41,62.91 280.41,63.86 280.49,63.94 283.18,63.94
+1.8V_RUN_CARD on TOP (solid shape): 275.56,63.23 275.56,62.34 275.89,62.01 275.89,61.05 275.82,60.97 275.51,60.97 275.44,61.05 275.44,62.11 275.36,62.19 275.36,63.23 275.41,63.28 275.51,63.28
+1.8V_RUN_CARD on IN2 (solid shape): 276.44,61.16 276.25,60.97 275.55,60.97 275.46,61.06 275.46,61.94 275.59,62.06 276.44,62.06
+1.8V_RUN_CARD on IN2 (solid shape): 281.38,63.69 281.38,63.33 280.85,62.8 280.31,62.8 279.93,62.42 279.42,62.42 279.42,63.36 280.01,63.94 281.13,63.94
+1.8V_RUN_UZ8 on TOP (solid shape): 212.24,52.08 212.24,51.73 211.68,51.73 211.68,51.19 212.24,51.19 212.24,50.94 211.23,50.94 211.03,51.13 210.46,51.13 210.4,51.19 210.4,51.64 210.27,51.76 208.24,51.76 208.18,51.83 208.18,52.46 208.24,52.53 211.8,52.53
+1.8VALWP on BOTTOM (solid shape): 178.52,62.18 178.52,61.48 178.27,61.22 177.89,61.61 177.82,61.61 177.51,61.29 177.51,61.22 177.89,60.84 177.63,60.59 177.63,60.02 177.82,59.83 177.82,59.51 177.32,59 175.67,60.65 175.41,60.65 174.78,61.29 174.78,61.35 176.49,63.07 177.63,63.07
+1VALWP on TOP (solid shape): 162.84,85.63 161.24,85.63 161.06,85.81 161.06,88.07 161.26,88.28 162.84,88.28
+1VALWP on BOTTOM (solid shape): 161.72,88.53 162.71,88.53 162.81,88.43 162.81,84.95 163.6,84.16 164.24,84.16 164.38,84.01 164.38,81.41 164.26,81.29 161.97,81.29 161.62,81.65 161.62,83.42 160.18,84.86 160.18,87.01 160.17,87.01 160.17,87.03 159.66,87.03 159.66,87.48 160.17,87.48 160.17,87.51 160.18,87.51 160.18,88.21 160.17,88.21 160.17,88.23 159.66,88.23 159.66,88.68 160.17,88.68 160.17,88.71 160.18,88.71 160.18,89.73 160.22,89.77 160.48,89.77
+1VALWP_B+ on TOP (solid shape): 153.58,83.09 154.15,83.09 154.19,83.05 154.19,81.66 154.12,81.58 153.63,81.58 152.88,82.33 152.88,83.11 153.08,83.31 153.36,83.31
+1VALWP_B+ on BOTTOM (solid shape): 150.65,84.26 152.34,84.26 152.92,83.68 154.86,83.68 154.86,81.67 153.62,81.67 152.92,82.37 150.13,82.37 149.53,82.97 149.3,82.97 149.2,83.07 148.66,83.07 148.66,83.55 147.29,83.55 147.29,83.07 146.99,83.07 146.99,84.34 147.39,84.75 150.16,84.75
+1VS_VCCIOP on BOTTOM (solid shape): 136.42,131.96 136.42,130.06 137.29,129.19 139.72,129.19 139.72,129.2 140.46,129.2 140.54,129.12 140.54,128.97 140.01,128.44 139.58,128.44 139.11,127.97 137.79,127.97 137.79,127.46 137.5,127.46 137.5,127.97 136.99,127.97 136.99,127.46 136.7,127.46 136.7,127.97 134.63,127.97 134.45,128.15 134.45,131.58 134.9,132.03 136.36,132.03
+2.5V_MEM on TOP (solid shape): 145.82,62.93 145.82,61.94 145.11,61.22 142.34,61.22 142.34,62.85 142.44,62.95 145.79,62.95
+2.5V_MEM on BOTTOM (solid shape): 143.53,62.47 143.53,61.22 143.28,60.97 142.21,60.97 142.06,61.12 142.06,62.7 142.14,62.77 143.23,62.77
+2.5V_VIN on TOP (solid shape): 151.98,62.81 151.98,61.22 152.81,60.4 152.81,58.71 153.09,58.42 153.09,57.13 153.06,57.1 152.23,57.1 151.98,57.35 151.98,60.15 151.73,60.4 151.03,60.4 150.9,60.53 150.9,62.81 151.03,62.94 151.85,62.94
+3.3V_1.8V_ESPI on TOP (solid shape): 145.38,84.97 145.38,84.21 145.12,83.96 145.12,82.62 144.8,82.62 144.61,82.81 144.61,84.15 144.74,84.28 144.74,84.91 144.87,85.04 145.31,85.04
+3.3V_1.8V_PGPPA on TOP (solid shape): 146.71,82.94 147.09,82.56 147.09,81.29 145.76,81.29 145.69,81.35 145.69,82.56 145.57,82.69 145.31,82.69 145.31,82.88 145.88,82.88 145.88,83.39 145.31,83.39 145.31,83.64 146.33,83.64 146.46,83.77 146.71,83.77
+3.3V_ALW on TOP (solid shape): 280.31,93.55 280.31,91.83 280.12,91.64 278.85,91.64 278.79,91.7 278.79,92.4 278.67,92.53 278.67,93.49 278.85,93.67 280.19,93.67
+3.3V_ALW on TOP (solid shape): 259.77,87.25 260.21,87.25 260.21,87.77 261.09,87.77 261.24,87.62 261.24,86.61 261.05,86.42 259.63,86.42 259.38,86.66 259.38,87.68 259.47,87.77 259.77,87.77
+3.3V_ALW on TOP (solid shape): 253.64,110.37 253.64,109.04 253.45,108.85 251.99,108.85 251.8,109.04 251.8,109.74 251.93,109.87 251.93,110.44 251.99,110.5 253.52,110.5
+3.3V_ALW on TOP (solid shape): 253.77,113.17 253.77,112.79 253.39,112.41 252.88,112.41 252.69,112.22 252.69,111.96 252.63,111.9 251.99,111.9 251.93,111.96 251.93,113.1 252.12,113.29 253.64,113.29
+3.3V_ALW on TOP (solid shape): 69.04,122.69 69.04,121.42 68.91,121.3 66.7,121.3 66.45,121.55 66.45,122.57 66.69,122.81 68.92,122.81
+3.3V_ALW on TOP (solid shape): 227.67,58.24 229.01,58.24 229.18,58.06 229.18,57.58 228.9,57.3 226.91,57.3 226.64,57.58 226.64,58.01 226.63,58.01 226.63,58.04 226.38,58.29 225.23,58.29 225.11,58.42 225.11,59.18 225.27,59.35 226.57,59.35
+3.3V_ALW on TOP (solid shape): 207.54,60.35 207.54,58.24 207.47,58.17 207.02,58.17 206.96,58.24 206.96,59.53 206.77,59.72 205.65,59.72 205.44,59.51 204.68,59.51 204.56,59.64 204.56,59.98 205.19,60.61 207.29,60.61
+3.3V_ALW on TOP (solid shape): 263.85,94.69 263.85,93.13 263.85,93.12 263.85,89.65 263.46,89.27 262.36,89.27 262.3,89.32 262.3,89.99 262.38,90.07 262.93,90.07 263.16,90.3 263.16,91.03 262.91,91.27 262.33,91.27 262.18,91.43 262.18,92.7 262.53,93.05 262.53,94.77 262.72,94.96 263.59,94.96
+3.3V_ALW on TOP (solid shape): 254.84,76.85 254.84,76.32 254.82,76.3 254.82,75.48 254.28,74.94 253.26,74.94 252.68,74.36 251.31,74.36 251.2,74.46 251.2,75.42 250.87,75.75 250.87,76.72 250.95,76.8 251.2,76.8 251.2,76.24 251.71,76.24 251.71,76.8 252.91,76.8 253.03,76.92 254.76,76.92
+3.3V_ALW on TOP (solid shape): 169.82,69.07 169.82,66.5 168.17,64.84 167.35,65.67 166.52,65.67 166.51,65.67 164.61,63.76 163.22,63.76 163.21,63.76 162.65,63.21 162.65,57.87 161.7,56.91 160.7,56.91 160.35,56.55 153.54,56.55 153.25,56.84 153.25,56.92 153.25,57.39 153.77,57.39 153.77,57.82 153.25,57.82 153.25,58.11 153.25,58.11 154.2,58.11 154.77,57.54 157.48,57.54 157.73,57.8 157.76,57.8 158.27,58.3 158.27,59.07 158.2,59.13 158.2,59.57 158.27,59.64 158.91,59.64 159.21,59.35 161.21,59.35 161.5,59.64 161.5,59.76 161.71,59.76 162.2,59.94 161.71,60.13 161.5,60.13 161.5,61.61 161.19,61.92 160.93,61.92 160.89,61.95 160.87,61.95 160.85,61.97 160.62,62.05 160.42,61.92 160,61.92 159.99,61.93 159.66,61.91 159.49,61.64 159.48,61.62 158.9,61.03 158.27,61.03 158.2,61.1 158.2,63.8 161.25,66.84 162.77,66.84 165.42,69.5 169.4,69.5
+3.3V_ALW on BOTTOM (solid shape): 224.31,67.45 224.31,66 223.29,66 223.29,67.45 223.42,67.57 224.18,67.57
+3.3V_ALW on BOTTOM (solid shape): 288.53,127.34 288.53,126.55 288.3,126.32 288.3,124.27 288.15,124.13 286.95,124.13 286.53,123.71 286.53,121.13 286.45,121.05 285.98,121.05 285.9,121.13 285.9,125.86 287.53,127.49 288.38,127.49
+3.3V_ALW on BOTTOM (solid shape): 153.07,85.74 153.07,84.39 153.32,84.14 154.88,84.14 154.89,84.12 154.89,83.91 154.88,83.89 152.89,83.89 152.39,84.4 152.39,85.69 152.52,85.83 152.53,85.83 152.6,85.9 152.91,85.9
+3.3V_ALW on BOTTOM (solid shape): 227.61,61.42 227.61,60.97 227.1,60.46 227.1,58.56 227.24,58.42 227.57,58.42 227.74,58.25 227.74,57.44 227.6,57.3 226.85,57.3 226.45,56.91 225.98,56.91 225.78,57.11 225.78,60.41 225.96,60.59 225.96,61.45 225.98,61.48 226.02,61.48 226.15,61.61 227.42,61.61
+3.3V_ALW on BOTTOM (solid shape): 158.41,115.31 158.41,114.23 157.62,113.45 157.62,113.21 157.48,113.07 157.48,112.13 157.4,112.05 157.17,112.05 157.01,112.22 157.01,113.04 156.49,113.56 154.54,113.56 154.54,114.58 156.87,114.58 157.38,115.09 157.38,115.4 157.45,115.48 158.24,115.48
+3.3V_ALW on BOTTOM (solid shape): 166.75,71.3 167.5,71.3 167.5,71.83 167.95,71.83 167.95,71.3 168.7,71.3 168.7,71.83 170,71.83 170.31,71.52 170.31,69.14 170.78,68.67 170.78,68.6 170.39,68.21 170.2,68.4 169.1,68.4 169.08,68.42 169.07,68.4 169.02,68.4 168.77,68.15 168.4,68.52 168.09,68.21 168.46,67.84 168.27,67.65 165.81,67.65 165.06,68.4 165.06,71.58 165.31,71.83 166.75,71.83
+3.3V_ALW on VCC: outline of 160 points within 35.97,65.92 299.03,136.03
+3.3V_ALW_DSW on TOP (solid shape): outline of 115 points within 122.15,90.57 126.36,98.49
+3.3V_ALW_PCH on TOP (solid shape): 142.07,71.18 142.07,70.9 141.48,70.31 141.26,70.31 140.37,71.2 140.37,72.02 140.5,72.15 141.1,72.15
+3.3V_ALW_PCH on TOP (solid shape): 148.87,65.99 148.87,64.9 148.82,64.85 148.31,64.85 147.93,65.24 147.62,65.24 147.22,65.64 147.22,65.64 146.86,66 146.86,66.45 147.41,66.99 147.87,66.99
+3.3V_ALW_PCH on TOP (solid shape): outline of 823 points within 122.67,97.02 150.2,105.55
+3.3V_ALW_PCH on BOTTOM (solid shape): 152.83,110 152.83,109.72 152.3,109.72 152.3,109.28 152.83,109.28 152.83,108.53 152.5,108.2 151.93,108.2 151.67,108.46 151.67,110.01 151.78,110.11 152.73,110.11
+3.3V_ALW_PCH on BOTTOM (solid shape): 136.71,122.22 136.71,121.8 136.54,121.63 134.15,121.63 133.76,121.23 131.41,121.23 131.34,121.3 131.34,122.11 131.55,122.31 133.05,122.31 133.19,122.45 136.48,122.45
+3.3V_ALW_PCH on IN1 (solid shape): outline of 255 points within 136.22,78.22 143.02,83.7
+3.3V_ALW_PCH on IN3 (solid shape): 137.05,78.52 137.27,78.3 137.26,78.27 137.24,78.1 137.3,77.94 137.3,77.19 137.45,77.04 137.45,76.86 140.84,73.47 140.84,71.14 140.58,71.14 139.52,72.2 139.54,72.23 139.52,72.6 139.17,72.75 139.15,72.75 136.24,75.66 136.24,78.57 136.4,78.73 136.6,78.73 136.61,78.73 137.05,78.73
+3.3V_ALW_PCH on IN3 (solid shape): outline of 376 points within 119.59,96.14 123.16,99.16
+3.3V_ALW_PCH on VCC: 141.44,82.69 141.44,84.42 141.73,84.72 144.91,84.72 146.39,86.2 146.39,87.75 145.19,88.95 145.19,99.37 143.34,101.21 143.34,105.19 143.58,105.42 150.14,105.42 150.14,92.93 150.84,92.23 150.84,86.5 150.29,86.5 146.48,82.69
+3.3V_ALW_PCH_UZ3 on TOP (solid shape): 151.03,64.72 151.03,64.34 150.84,64.15 150.2,64.15 149.49,64.86 149.08,64.86 149.02,64.92 149.02,65.2 149.55,65.2 149.55,65.63 149.02,65.63 149.02,65.93 149.08,65.99 149.75,65.99
+3.3V_ALW_PCH_UZ3 on TOP (solid shape): 156.93,59.57 156.93,59.07 156.87,59 156.36,59 156.04,58.68 155.22,58.68 155.12,58.58 155.12,58.2 155.09,58.18 154.71,58.18 154.46,58.43 153.44,58.43 152.93,58.94 152.93,59.51 153.76,59.51 153.82,59.45 155.6,59.45 155.79,59.64 156.87,59.64
+3.3V_ALW_UE1 on TOP (solid shape): 252.3,79.26 252.3,77.67 252.06,77.43 252.06,77.04 251.97,76.95 250.98,76.95 250.95,76.97 250.95,77.33 251.48,77.86 251.48,79.39 251.51,79.41 252.15,79.41
+3.3V_ALWP on TOP (solid shape): 167.47,73.86 165.76,73.86 165.44,74.18 165.44,78.5 165.7,78.75 167.47,78.75
+3.3V_ALWP on BOTTOM (solid shape): 167.47,74.05 167.92,73.61 169,73.61 169.25,73.35 169.25,72.02 169.2,71.96 168.58,71.96 168.58,71.43 168.08,71.43 168.08,71.96 167.38,71.96 167.38,71.43 166.88,71.43 166.88,71.96 163.75,71.96 163.54,72.17 163.54,78.37 163.98,78.81 167.47,78.81
+3.3V_CAM on TOP (solid shape): 57.78,129.96 57.78,125.32 57.45,124.99 56.48,124.99 56.16,125.31 56.16,128.6 56.32,128.76 56.32,130.81 56.42,130.91 56.83,130.91
+3.3V_CAM on BOTTOM (solid shape): 56.39,133.31 56.39,131.98 56.54,131.83 56.54,131.82 56.54,131.2 56.69,131.06 56.69,131.04 57.09,130.64 57.09,129.8 56.97,129.69 56.45,129.69 56.25,129.89 56.25,131.06 56.11,131.2 56.11,133.31 56.16,133.36 56.34,133.36
+3.3V_EC_PLL on TOP (solid shape): 250.87,83.96 250.87,83.02 250.6,82.74 250.6,80.91 250.38,80.69 250.38,79.82 250.27,79.72 249.71,79.72 249.7,79.73 249.7,80.65 250.19,81.14 250.19,82.97 250.52,83.3 250.52,83.93 250.62,84.03 250.8,84.03
+3.3V_HDD_M2 on TOP (solid shape): outline of 587 points within 10.06,40.63 29.42,46.68
+3.3V_HDD_M2 on BOTTOM (solid shape): 26.89,49.48 26.91,49.48 26.91,49.47 27.62,49.47 27.62,49.48 27.64,49.48 27.64,49.99 28.09,49.99 28.09,49.48 28.11,49.48 28.11,49.47 28.77,49.47 28.83,49.41 28.83,48.37 28.6,48.14 28.6,45.6 28.47,45.48 26.06,45.48 25.69,45.84 25.69,49.37 25.79,49.47 26.42,49.47 26.42,49.48 26.44,49.48 26.44,49.99 26.89,49.99
+3.3V_LAN on TOP (solid shape): 247.89,113.9 247.89,112.62 247.81,112.53 246.66,112.53 246.53,112.66 246.53,113.84 246.64,113.95 247.85,113.95
+3.3V_LAN on TOP (solid shape): 286.59,120.41 286.59,119.35 286.5,119.25 284.27,119.25 284,119.52 284,120.22 284.23,120.45 286.05,120.45 286.1,120.51 286.49,120.51
+3.3V_LAN on BOTTOM (solid shape): 240.66,125.45 240.66,124.62 240.88,124.41 241.77,124.41 241.9,124.28 241.9,123.77 241.71,123.58 240.31,123.58 239.99,123.9 239.99,125.49 240.63,125.49
+3.3V_LAN on IN2 (solid shape): 285.15,121.14 285.15,120.07 284.99,119.91 284.14,119.91 284.01,120.04 284.01,121.11 284.1,121.19 285.09,121.19
+3.3V_LAN on IN2 (solid shape): 254.41,131.52 254.41,129.08 254.28,128.95 253.19,128.95 253.1,129.04 253.1,130.03 251.61,131.52 244.44,131.52 243.86,130.95 243.61,130.95 243.36,131.2 242.4,131.2 241.9,130.69 241.9,126.62 242.39,126.12 242.39,124.42 243.51,123.3 243.51,120.76 243.67,120.6 243.67,114.95 244.31,114.31 247.42,114.31 247.61,114.12 247.61,112.66 247.48,112.53 242.72,112.53 241.77,113.49 241.77,118.37 240.88,119.26 240.88,119.77 242.11,121 242.11,122.67 241.78,123 240.63,123 240.12,123.51 240.12,131.77 241.07,132.73 253.2,132.73
+3.3V_LAN_OUT on TOP (solid shape): 245.77,123.45 245.77,121.88 244.98,121.09 244.98,120.69 244.85,120.56 244.37,120.56 244.35,120.58 244.35,121.07 244.54,121.26 244.54,121.66 245.16,122.29 245.16,123.43 245.21,123.48 245.74,123.48
+3.3V_LAN_OUT on BOTTOM (solid shape): outline of 231 points within 241.39,121.17 248.63,126.69
+3.3V_LAN_OUT on IN2 (solid shape): 250.4,127.72 250.4,124.99 250.4,124.98 250.4,120.28 249.64,119.52 246.02,119.52 245.71,119.84 245.01,119.84 244.31,120.53 244.31,121.79 244.36,121.95 244.34,122.11 244.33,122.14 244.5,122.31 245.52,122.31 245.64,122.18 245.64,121.3 246.21,120.72 248.82,120.72 249.2,121.11 249.2,124.98 248.12,126.06 248.12,126.25 248.82,126.95 248.82,128.18 247.8,129.2 246.84,129.2 246.62,129.41 246.62,129.79 246.63,129.86 246.62,129.93 246.62,130.27 246.79,130.44 247.67,130.44
+3.3V_LAN_UZ2 on TOP (solid shape): 250.07,113.77 250.07,113.06 250.69,112.44 250.69,111.93 250.61,111.85 249.86,111.85 248.86,112.85 248.06,112.85 248.06,113.1 248.63,113.1 248.63,113.61 248.06,113.61 248.06,113.9 248.1,113.94 249.9,113.94
+3.3V_M_TPM on BOTTOM (solid shape): 153.83,109.99 153.83,108.56 153.72,108.44 153.05,108.44 152.98,108.51 152.98,109.41 152.42,109.41 152.42,109.59 152.98,109.59 152.98,110.08 153,110.09 153.73,110.09
+3.3V_M_TPM on BOTTOM (solid shape): 163.49,109.18 163.49,104.72 163.16,104.39 161.67,104.39 161.65,104.41 161.65,104.97 161.76,105.08 162.25,105.08 162.25,105.12 162.52,105.38 162.52,108.53 161.97,109.08 161.26,109.08 161.19,109.15 161.19,109.28 161.26,109.36 162.01,109.36 162.08,109.42 163.24,109.42
+3.3V_M_TPM on IN2 (solid shape): 155.28,107.63 155.55,107.45 155.86,107.56 155.93,107.6 156.01,107.57 156.89,106.68 156.89,106.62 157.08,106.27 157.47,106.31 157.53,106.33 157.6,106.31 157.88,106.23 158.13,106.39 158.53,106.39 158.83,106.22 159.13,106.39 160.78,106.39 161.05,106.26 161.32,106.39 161.95,106.39 163.45,104.89 163.45,104.52 163.1,104.18 161.68,104.18 161.03,104.82 156.62,104.82 156.38,104.97 156.11,104.91 156.08,104.88 154.33,106.63 154.33,107.44 154.52,107.63
+3.3V_MMI_AUX on TOP (solid shape): 276.5,71.33 276.5,68.31 276.43,68.24 276.27,68.24 275.97,67.93 275.97,66.51 275.92,66.46 275.82,66.46 275.77,66.51 275.77,67.42 275.65,67.53 275.65,67.87 274.44,69.09 272.68,69.09 272.52,69.25 272.52,71.38 272.81,71.68 274.33,71.68 274.34,71.69 276.15,71.69
+3.3V_MMI_IN on TOP (solid shape): 274.37,74.8 274.37,74.55 275.41,73.51 275.41,72.45 275.33,72.38 274.38,72.38 273.97,71.97 272.34,71.97 272.11,72.2 272.11,72.7 272.64,72.7 272.64,73.21 272.11,73.21 272.11,73.5 272.64,73.5 272.64,74.01 272.11,74.01 272.11,74.87 272.37,75.12 274.04,75.12
+3.3V_MMI_IN on TOP (solid shape): 274.78,63.21 274.78,62.16 274.73,62.11 274.73,60.17 274.59,60.03 274.59,56.99 274.32,56.73 273.76,56.73 273.15,57.33 273.15,57.35 272.82,57.68 272.82,58.73 272.31,59.23 272.31,59.45 272.39,59.52 273.06,59.52 273.67,59.52 273.99,59.84 273.99,60.78 274.36,61.14 274.36,61.9 274.53,62.08 274.53,62.36 274.57,62.39 274.57,63.21 274.62,63.27 274.71,63.27
+3.3V_MMI_IN on IN2 (solid shape): outline of 101 points within 270.28,58.46 274.26,73.25
+3.3V_RUN on TOP (solid shape): 28.98,50.43 28.73,50.18 26.25,50.18 25.93,50.49 25.93,54.43 28.98,54.43
+3.3V_RUN on TOP (solid shape): 37.11,68.53 37.11,66.18 36.6,65.67 33.11,65.67 32.85,65.92 32.85,68.21 33.43,68.78 36.85,68.78
+3.3V_RUN on TOP (solid shape): 17.36,97.82 16.84,97.82 16.84,97.31 17.36,97.31 17.36,97.02 16.84,97.02 16.84,96.51 17.36,96.51 17.36,96.15 15.01,96.15 14.76,96.4 14.76,98.05 14.88,98.18 17.36,98.18
+3.3V_RUN on TOP (solid shape): 157.44,67.19 157.44,65.92 157.19,65.67 153.95,65.67 153.95,66.19 153.24,66.19 153.24,65.67 152.75,65.67 152.75,66.19 152.04,66.19 152.04,65.67 151.48,65.67 151.36,65.8 151.36,67.27 151.47,67.38 157.25,67.38
+3.3V_RUN on TOP (solid shape): 207.26,57.05 207.26,56.62 206.7,56.62 206.7,56.18 207.26,56.18 207.26,55.77 207.45,55.59 207.45,54.96 207.38,54.9 206.97,54.9 206.91,54.96 206.91,55.31 206.36,55.85 206.15,56.07 206.15,56.95 206.35,57.15 207.16,57.15
+3.3V_RUN on TOP (solid shape): 245.52,66.56 246.02,66.56 246.02,67.13 246.34,67.13 246.47,67 246.47,66.05 245.77,65.35 245.77,64.59 245.71,64.53 245.07,64.53 244.44,65.16 244.35,65.16 244.35,65.64 244.65,65.64 245.26,66.25 245.26,67.13 245.52,67.13
+3.3V_RUN on TOP (solid shape): 270,75.76 271.65,75.76 271.98,75.42 271.98,73.88 272.5,73.88 272.51,73.86 272.51,73.63 271.98,73.63 271.98,73.08 272.51,73.08 272.51,72.83 271.98,72.83 271.98,71.72 271.84,71.58 270.65,71.58 270.65,71.62 270.56,72.23 270.38,72.81 269.09,74.45 267.12,75.15 267.11,75.17 267.11,76.36 267.28,76.54 269.21,76.54
+3.3V_RUN on BOTTOM (solid shape): 247.88,55.9 247.88,54.43 247.7,54.25 246.91,54.25 246.78,54.38 246.78,55.85 246.96,56.03 247.75,56.03
+3.3V_RUN on BOTTOM (solid shape): 28.84,51.52 28.84,49.67 28.78,49.6 28.22,49.6 28.22,50.12 27.51,50.12 27.51,49.6 27.02,49.6 27.02,50.12 26.31,50.12 26.31,49.6 25.74,49.6 25.74,51.38 26,51.64 28.73,51.64
+3.3V_RUN on BOTTOM (solid shape): 149.69,110.82 148.87,110.82 148.49,110.44 148.49,109.48 148.68,109.29 149.12,109.29 149.12,108.91 148.68,108.91 148.3,108.53 147.66,108.53 147.47,108.34 147.47,107.71 146.96,107.71 146.96,108.47 147.22,108.72 147.22,109.29 147.28,109.36 147.92,109.36 148.04,109.48 148.04,109.93 147.85,110.12 147.28,110.12 147.22,110.18 147.22,110.82 147.28,110.88 148.36,110.88 148.8,111.33 149.69,111.33
+3.3V_RUN on IN2 (solid shape): 22.57,91.77 22.57,89.04 22.38,88.85 21.17,88.85 20.92,89.1 20.92,92.02 22.31,92.02
+3.3V_RUN on IN2 (solid shape): 16.79,96.53 15.96,96.53 15.71,96.28 14.95,96.28 14.76,96.47 14.76,97.93 14.88,98.05 16.79,98.05
+3.3V_RUN on IN2 (solid shape): 140.56,82.76 137.11,82.76 136.98,82.64 136.5,82.64 136.37,82.76 136.37,83.12 136.78,83.53 140.56,83.53
+3.3V_RUN on IN2 (solid shape): 157.02,66.69 157.02,65.9 156.89,65.77 154.41,65.77 154.2,65.97 154.05,65.97 154,66.03 154,66.74 154.71,66.74 154.79,66.81 156.89,66.81
+3.3V_RUN on VCC: 135.13,82.69 133.37,84.44 133.37,94.52 134.45,95.6 134.45,108.07 133.63,108.89 133.63,109.7 142.05,118.12 149.27,118.12 150.14,117.25 150.14,105.93 143.37,105.93 142.84,105.4 142.84,101 144.68,99.16 144.68,88.74 145.88,87.54 145.88,86.41 144.7,85.23 141.52,85.23 140.93,84.63 140.93,82.69
+3.3V_RUN on VCC: 156.97,63 152.47,67.51 144.11,67.51 143.47,66.88 34,66.88 34,70.28 21.3,82.98 21.3,90.77 23.39,92.87 23.39,105.99 29.36,111.96 29.36,114.84 41.66,127.14 77.85,127.14 80.46,129.74 104.08,129.74 105.54,131.2 126.28,131.2 126.52,130.97 126.52,128.6 122.13,128.6 121.18,127.65 81.45,127.65 80.85,127.04 80.82,127.01 78.6,124.79 48.62,124.79 41.36,117.53 41.36,116.41 40.3,116.41 39.27,115.37 39.27,109.17 37.13,109.17 36.41,108.45 36.41,93.89 37.07,93.23 43.48,93.23 43.71,93 43.71,92.19 43.42,91.9 36.56,91.9 35.46,90.79 35.46,86.33 36.41,85.38 36.41,79.28 42.65,73.04 42.82,73.04 48.8,73.04 49.94,74.18 61.95,74.18 63.08,73.05 156.13,73.1 163.81,65.42 232.92,65.42 242.64,75.13 258.22,75.13 260.25,77.16 268.31,77.16 268.31,75.68 268.08,75.45 265.09,75.45 262.87,73.23 248.01,73.23 237.15,62.37 163.03,62.37 162.39,63
+3.3V_RUN_AUDIO on TOP (solid shape): 262.28,67.7 262.28,67.13 261.9,66.75 261.9,66.18 261.39,66.18 261.39,66.62 261.2,66.81 261.2,67.7 261.33,67.83 262.15,67.83
+3.3V_RUN_AUDIO on IN1 (solid shape): outline of 364 points within 248.69,66.75 261.75,69.92
+3.3V_RUN_AUDIO on TOP: 245.65,66.76 245.65,67.27 245.16,67.27 245.16,67.62 245.23,67.71 245.34,67.68 245.84,67.63 245.89,68.13 245.87,68.2 245.89,68.26 245.93,68.31 248.11,68.31 249.21,69.42 252.25,69.42 252.25,68.84 252.37,68.72 253.14,68.72 253.9,67.96 254.15,67.96 254.41,67.7 254.41,67 253.9,67 253.9,67.32 253.26,67.96 251.87,67.96 251.67,67.77 251.67,67.54 251.32,67.18 249.33,67.18 248.91,66.76 248.21,66.76 248.21,67.27 247.77,67.27 247.77,66.76 246.6,66.76 246.6,67.06 246.4,67.25 246.4,67.27 245.88,67.27 245.88,66.76
+3.3V_RUN_AUDIO_DVDD on TOP (solid shape): 262.04,65.76 262.04,65.25 261.95,65.16 260.69,65.16 260.5,64.97 260.5,64.15 260.04,63.69 260.04,63.16 259.83,62.94 259.49,62.94 259.42,63 259.42,63.79 260.06,64.43 260.06,65.73 260.15,65.82 261.97,65.82
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 248.82,66.43 248.82,65.25 248.72,65.25 247.99,64.53 247.1,64.53 247.04,64.59 247.04,66.43 247.19,66.58 248.66,66.58
+3.3V_RUN_CARD on TOP (solid shape): 285.42,56.98 286.56,56.98 286.71,56.83 286.71,56.5 286.59,56.37 282.83,56.37 282.66,56.21 279.01,56.21 278.89,56.32 278.89,57.06 279.12,57.29 282.35,57.29 282.47,57.41 284.99,57.41
+3.3V_RUN_CARD on IN2 (solid shape): 280.57,57.16 280.57,56.78 280.12,56.34 278.79,56.34 278.79,57.35 280.38,57.35
+3.3V_RUN_CARD on IN2 (solid shape): 275.3,62.05 275.3,61.16 275.05,60.91 275.05,60.26 274.94,60.16 274.18,60.16 274.04,60.3 274.04,62.06 274.15,62.18 275.17,62.18
+3.3V_RUN_UZ3 on TOP (solid shape): 152.62,65.54 152.64,65.54 152.64,65.54 153.35,65.54 153.35,65.54 153.37,65.54 153.37,66.06 153.82,66.06 153.82,65.54 153.84,65.54 153.84,65.54 156.85,65.54 157.25,65.14 157.25,62.18 156.93,61.86 156.93,61.1 156.87,61.03 156.23,61.03 155.98,61.29 154.9,61.29 154.84,61.35 154.84,61.8 154.65,61.99 154.2,61.99 153.95,62.24 153.95,62.81 152.49,64.27 151.76,64.27 151.36,64.68 151.36,65.41 151.49,65.54 152.15,65.54 152.15,65.54 152.17,65.54 152.17,66.06 152.62,66.06
+3.3V_TBT on TOP (solid shape): 18.69,99.77 18.69,98.23 18.95,97.98 22.38,97.98 22.68,97.67 23.71,97.67 23.82,97.56 24.61,97.56 24.65,97.6 24.81,97.6 24.86,97.54 24.86,97.45 24.86,97.42 24.76,97.32 24.75,97.32 24.73,97.29 24.65,97.29 24.48,97.12 24.48,96.98 24.35,96.85 24.12,96.85 23.47,96.2 23.45,96.2 23.42,96.18 17.5,96.18 17.5,96.62 17.49,96.62 17.49,96.64 16.97,96.64 16.97,96.89 17.49,96.89 17.49,96.91 17.5,96.91 17.5,97.42 17.49,97.42 17.49,97.44 16.97,97.44 16.97,97.69 17.49,97.69 17.52,97.69 17.52,98.18 17.75,98.41 17.75,99.78 17.87,99.9 18.57,99.9
+3.3V_TBT on IN1 (solid shape): 27.39,100.79 27.38,100.64 27.39,100.54 27.39,100.09 27.01,99.71 25.55,99.71 24.6,98.75 24.6,96.72 24.41,96.53 23.39,96.53 23.27,96.66 23.27,99.2 24.34,100.28 26.69,100.28 26.82,100.4 26.82,100.79 26.95,100.91 27.27,100.91
+3.3V_TBT_LC on BOTTOM (solid shape): 34.85,95.72 34.54,95.41 33.63,95.41 33.63,96.89 34.09,96.89 34.31,97.12 34.31,98.61 34.34,98.64 34.85,98.64
+3.3V_TBT_S0 on IN2 (solid shape): 30,106.25 30,105.29 29.98,105.19 30,105.08 30,103.99 29.99,103.99 29.98,103.89 29.99,103.79 30,103.76 30.08,103.63 30.21,103.55 30.22,103.55 30.65,103.12 30.66,103.11 30.85,102.91 31.13,102.91 31.16,102.92 31.27,102.82 31.27,102.44 31.14,102.31 30.44,102.31 30,102.75 30,102.75 29.94,102.84 29.85,102.9 29.85,102.9 29.36,103.39 29.36,103.74 29.36,103.75 29.39,103.89 29.36,104.02 29.36,104.03 29.36,104.39 29.36,104.4 29.39,104.54 29.36,104.67 29.36,104.68 29.36,105.04 29.37,105.05 29.39,105.19 29.37,105.33 29.36,105.36 29.29,105.44 29.23,105.48 29.11,105.61 25.49,105.61 24.71,104.84 24.71,100.91 23.95,100.15 17.55,100.15 17.36,100.34 17.36,102 17.42,102.06 17.89,102.06 18.57,101.38 22.73,101.38 23.49,102.14 23.49,105.21 24.92,106.63 29.62,106.63
+3.3V_TBT_S0 on TOP: 18.63,101.86 18.44,102.06 16.66,102.06 16.53,101.93 16.53,100.53 16.79,100.28 18.44,100.28 18.63,100.47
+3.3V_TBT_S0 on BOTTOM: 17.93,102.82 18.63,102.82 18.69,102.75 18.69,99.71 18.63,99.64 17.68,99.64 17.23,100.09 17.23,101.86 17.36,101.99 17.74,101.99 17.8,102.06 17.8,102.69
+3.3V_TBT_SX on TOP (solid shape): 28.28,92.11 28.28,91.33 28.01,91.06 27.69,91.06 27.49,90.86 26.61,90.86 25.74,89.99 25.74,88.36 25.63,88.25 22.73,88.25 22.68,88.3 22.68,89.04 22.81,89.16 24.47,89.16 24.6,89.29 24.6,89.99 25.74,91.13 25.74,92.09 26.44,92.09 26.54,91.98 26.54,91.47 26.63,91.38 27.35,91.38 27.55,91.57 27.55,92.02 27.68,92.15 28.23,92.15
+3.3V_TP on TOP (solid shape): 210.1,60 210.1,59.3 209.84,59.04 209.84,58.22 208.91,57.29 208.91,55.92 208.9,55.92 208.84,55.85 207.48,55.85 207.42,55.92 207.42,56.91 209.04,58.53 209.04,59.09 209.61,59.66 209.61,60.04 209.68,60.11 209.99,60.11
+3.3V_TSP on TOP (solid shape): 51.33,131.84 51.33,131.58 51.14,131.39 51.14,129.23 50.63,129.23 50.63,130.31 50.57,130.38 50.57,131.58 50.95,131.96 51.21,131.96
+3.3V_VDD_PIC on TOP (solid shape): 30.5,89.62 34.17,89.62 34.31,89.48 34.39,89.48 34.39,88.47 34.12,88.47 33.55,89.04 30.12,89.04 29.23,89.93 28.03,89.93 27.71,89.61 27.71,88.91 27.01,88.21 26,88.21 25.93,88.28 25.93,88.59 26.5,88.59 26.5,89.1 25.93,89.1 25.93,89.61 26.12,89.8 27.08,89.8 27.9,90.63 29.5,90.63
+3.3V_VDD_PIC on BOTTOM (solid shape): 24.66,65.73 24.66,64.91 23.63,64.91 22.68,63.96 19.96,63.96 19.58,64.34 19.58,65.54 19.71,65.67 20.15,65.67 20.28,65.54 20.28,64.84 20.66,64.46 22.06,64.46 22.88,65.29 22.88,65.99 24.41,65.99
+3.3V_VDD_PIC_PDA on TOP (solid shape): 35.71,89.38 35.71,87.89 35.52,87.7 35.52,87.13 34.95,87.13 34.95,87.96 35.13,88.14 35.13,89.47 35.14,89.48 35.61,89.48
+3.3V_WLAN on TOP (solid shape): 242.44,63.6 242.44,61.56 242.37,61.48 240.97,61.48 240.87,61.58 240.87,63.56 241.03,63.72 242.33,63.72
+3.3V_WLAN on TOP (solid shape): 242.64,80.92 242.64,78.93 241.78,78.07 241.78,77.84 241.64,77.7 241.15,77.7 241.01,77.84 241.01,81.07 241.04,81.1 242.47,81.1
+3.3V_WLAN on TOP (solid shape): 248.74,107.51 249.24,107.51 249.24,108.03 249.54,108.03 249.54,107.51 250.04,107.51 250.04,108.03 250.59,108.03 250.68,107.94 250.68,106.33 249.11,104.76 247.33,104.76 246.68,105.41 244.34,105.41 244.15,105.21 244.15,103.81 244.7,103.25 244.7,100.52 244.5,100.33 242.85,100.33 242.69,100.33 242.53,100.48 242.53,101.91 242.07,102.38 242.07,106.33 242.36,106.63 247.23,106.63 247.67,107.07 247.67,107.96 247.75,108.03 248.74,108.03
+3.3V_WLAN on BOTTOM (solid shape): 244.58,101.85 244.58,101.2 243.05,99.68 241.2,99.68 241.2,101.17 242.16,102.13 244.3,102.13
+3.3V_WLAN on BOTTOM (solid shape): outline of 338 points within 239.47,61.29 246.5,86.4
+3.3V_WLAN_UZ2 on TOP (solid shape): 250.65,110.45 250.65,108.33 250.48,108.16 249.94,108.16 249.91,108.16 249.91,107.64 249.66,107.64 249.66,108.16 249.64,108.16 249.14,108.16 249.11,108.16 249.11,107.64 248.86,107.64 248.86,108.16 248.84,108.16 248.37,108.16 248.31,108.22 248.31,110.25 248.5,110.44 249.13,110.44 249.2,110.5 250.6,110.5
+3.3V_WWAN on TOP (solid shape): 276.31,97.55 276.31,96.85 275.8,96.85 275.8,96.14 276.31,96.14 276.31,95.65 275.8,95.65 275.8,94.94 276.31,94.94 276.31,94.37 276.31,94.37 276.02,94.08 274.67,94.08 274.28,94.48 274.28,97.5 274.5,97.72 276.14,97.72
+3.3V_WWAN on TOP (solid shape): 239.04,112.91 239.04,109.42 239.36,109.1 239.36,106.31 238.86,105.82 238.83,105.82 238.83,105.79 238.72,105.67 238.72,101.47 238.09,100.84 238.09,100.82 237.26,100 237.26,97.7 237.48,97.48 237.95,97.48 238.09,97.34 238.09,94 238.02,94 237.84,93.82 237.13,93.82 236.87,93.56 236.75,93.56 236.33,93.97 236.16,93.97 236.12,94.01 236.12,96.99 235.49,97.61 235.49,101.31 236.12,101.93 236.12,104.86 236.14,104.93 236.21,104.96 236.5,105.16 236.49,105.5 236.46,105.54 236.69,105.76 236.69,106.63 237.2,107.14 237.2,112.85 237.51,113.17 238.78,113.17
+3.3V_WWAN on BOTTOM (solid shape): 238.73,112.96 238.73,110.93 238.63,110.83 237.23,110.83 237.13,110.93 237.13,113.04 237.26,113.17 238.53,113.17
+3.3V_WWAN on BOTTOM (solid shape): 276.5,96.59 276.5,94.58 276.25,94.32 274.33,94.32 274.03,94.63 274.03,95.45 272.95,96.53 272.95,98.37 273.26,98.69 274.41,98.69
+3.3V_WWAN on BOTTOM (solid shape): 237.01,95.11 237.01,94.77 237.13,94.65 238.62,94.65 238.71,94.56 238.71,91.57 236.63,89.48 236.63,88.53 236.56,88.47 233.89,88.47 233.89,89.83 235.14,91.07 235.86,91.07 236.73,91.93 236.73,92.92 236.48,93.17 236.48,95.1 236.57,95.19 236.93,95.19
+3.3V_WWAN on BOTTOM (solid shape): 242.78,107.39 253.83,107.39 254.66,108.21 256.82,108.21 257.35,107.68 269.21,107.68 272.13,104.76 272.13,103.24 269.59,103.24 269.59,103.62 267.76,105.46 252.53,105.46 252.42,105.35 242.72,105.35 242.18,105.9 240.66,105.9 239.28,107.28 254.81,107.28 254.81,107.22 254.83,107.17 254.85,107.12 254.87,107.07 254.91,107.03 254.94,107 254.99,106.97 255.04,106.94 255.09,106.93 255.14,106.92 255.19,106.92 255.25,106.93 255.3,106.94 255.35,106.97 255.39,107 255.43,107.03 255.46,107.07 255.49,107.12 255.51,107.17 255.52,107.22 255.52,107.28 255.52,107.33 255.51,107.38 255.49,107.43 255.46,107.48 255.43,107.52 255.39,107.55 255.35,107.58 255.3,107.61 255.25,107.62 255.19,107.63 255.14,107.63 255.09,107.62 255.04,107.61 254.99,107.58 254.94,107.55 254.91,107.52 254.87,107.48 254.85,107.43 254.83,107.38 254.81,107.33 254.81,107.28 239.28,107.28 239.17,107.39 237.83,107.39 237.64,107.58 237.64,108.91 237.83,109.1 238.72,109.1 239.1,109.48 240.69,109.48
+3.3V_WWAN_UZ4 on TOP (solid shape): 278.47,97.48 278.47,93.23 277.52,92.28 277.52,91.7 277.46,91.64 276.38,91.64 276.06,91.96 275.49,91.96 275.49,92.78 275.49,92.79 275.49,93.08 276.45,94.04 276.45,95.05 276.44,95.05 276.44,95.07 275.92,95.07 275.92,95.52 276.44,95.52 276.44,95.54 276.45,95.54 276.45,96.25 276.44,96.25 276.44,96.27 275.92,96.27 275.92,96.72 276.44,96.72 276.44,96.74 276.45,96.74 276.45,97.55 276.65,97.76 278.2,97.76
+5V_ALW on TOP (solid shape): 52.04,92.14 52.04,92.06 52.7,91.4 52.7,91.12 52.6,91.02 52.35,91.02 52.17,91.2 51.51,91.2 51.43,91.27 51.43,92.14 51.48,92.19 51.99,92.19
+5V_ALW on TOP (solid shape): 275.66,75.56 275.66,74.56 275.41,74.31 274.99,74.31 274.75,74.54 274.75,75.58 274.83,75.65 275.58,75.65
+5V_ALW on TOP (solid shape): 279.74,90.12 280.19,90.12 280.31,90.24 280.57,90.24 280.82,89.99 280.82,88.66 280.5,88.34 279.04,88.34 278.79,88.59 278.79,90.18 278.85,90.24 279.61,90.24
+5V_ALW on TOP (solid shape): 201.47,58.23 201.47,57.41 201.95,56.93 201.95,54.52 201.42,53.99 199.19,53.99 199.03,54.14 199.03,55 199.55,55 199.55,55.71 199.03,55.71 199.03,56.2 199.55,56.2 199.55,56.91 199.03,56.91 199.03,58.11 199.35,58.43 201.27,58.43
+5V_ALW on TOP (solid shape): 275.88,79.83 278.94,79.83 279.03,79.74 279.03,77.21 278.73,76.91 278.68,76.86 277.45,76.86 277.38,76.94 277.38,77.71 277.46,77.78 277.46,78.37 277.2,78.62 276,78.62 275.89,78.73 275.89,78.99 275.55,79.33 274.98,79.33 274.9,79.42 274.9,79.9 274.96,79.97 275.74,79.97
+5V_ALW on BOTTOM (solid shape): 20.31,53.56 20.31,51.79 20.09,51.57 18.2,51.57 17.99,51.77 17.99,53.53 18.18,53.71 20.16,53.71
+5V_ALW on BOTTOM (solid shape): 147.09,129.23 147.09,127.71 146.9,127.52 145.2,127.52 145.02,127.7 145.02,128.32 145.55,128.32 145.55,128.75 145.02,128.75 145.02,129.16 145.29,129.42 146.9,129.42
+5V_ALW on BOTTOM (solid shape): 162.97,127.77 162.97,126.38 162.77,126.19 161.1,126.19 160.91,126.38 160.91,126.92 161.45,126.92 161.45,127.36 160.91,127.36 160.91,127.81 161.06,127.96 162.77,127.96
+5V_ALW on BOTTOM (solid shape): 21.67,77.69 21.67,77.06 22.19,77.06 22.19,76.56 21.67,76.56 21.67,75.86 22.19,75.86 22.19,75.36 21.67,75.36 21.67,74.72 21.64,74.69 20.15,74.69 19.96,74.88 19.96,77.42 20.28,77.73 21.62,77.73
+5V_ALW on IN2 (solid shape): outline of 186 points within 72.41,129.42 87.78,135.65
+5V_ALW on VCC: outline of 153 points within 14.31,48.13 282.09,135.68
+5V_ALW_PDA on TOP (solid shape): 34.32,78.56 34.35,78.48 34.3,78.4 34.19,78 34.55,77.8 34.58,77.81 34.78,77.6 34.78,76.37 34.37,75.96 32.59,75.96 32.43,76.11 32.43,76.62 32.47,76.63 32.74,76.98 32.45,77.32 32.45,77.35 32.44,77.39 32.44,78.52 32.51,78.6 34.28,78.6
+5V_ALW_PDA on BOTTOM (solid shape): outline of 259 points within 21.81,73.8 35.39,77.81
+5V_ALWP on TOP (solid shape): 198.9,57.42 198.9,56.8 198.91,56.8 198.91,56.78 199.42,56.78 199.42,56.33 198.91,56.33 198.91,56.31 198.9,56.31 198.9,55.6 198.91,55.6 198.91,55.58 199.42,55.58 199.42,55.15 199.4,55.13 198.91,55.13 198.91,55.12 198.86,55.12 198.86,54.09 199.15,53.8 200.16,53.8 200.28,53.68 200.28,52.44 200.18,52.33 196.34,52.33 195.99,52.69 195.99,57.29 196.34,57.64 198.68,57.64
