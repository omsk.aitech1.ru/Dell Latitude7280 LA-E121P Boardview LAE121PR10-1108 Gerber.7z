# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SDIN0_R: length 2.1
  TOP w0.112: RA9.2 256.56,65.01 256.73,64.85 UA1.8
HDA_SDOUT: length 13.9
  TOP w0.112: v2(122.17,81.7) 122.17,81.68 122.6,81.25 122.6,80.94 CC333.1 123.23,79.37 RC187.1 RC223.2 RC94.2
  BOTTOM w0.076: UC1.BB22 120.48,90.23 120.48,89.46 120.76,89.18 120.76,87.86 121.08,87.35 121.08,86.85
  BOTTOM w0.102: v2(122.17,81.7) 122.03,81.86 122.03,81.86 121.79,82.21 v1(121.19,86.13) 121.08,86.85
HDA_SDOUT_R: length 149.9
  TOP w0.112: v2(258.57,64.58) 257.93,63.93 UA1.5 ; RC94.1 125.31,76.45 v1(126.9,76.45) 140.8,76.45 148.14,69.11 162.23,69.11 164.55,71.44 179.01,71.44 182.13,68.32 184.79,68.32 188.35,66.78 226.3,66.78 227.51,67.99 231.62,67.99 231.9,67.71 233.93,67.71 235.86,69.63 238.57,69.63 239.96,71.03 243.1,71.03 243.8,71.73 255.69,71.73 v2(256.82,70.6)
  BOTTOM w0.119: v2(256.82,70.6) 256.61,70.39 256.61,68.18 258.57,66.22 v2(258.57,64.58)
HDA_SYNC: length 12.1
  TOP w0.112: RC92.2 119.98,81.09 120.5,81.61 v2(120.74,81.61)
  BOTTOM w0.076: UC1.BA22 120.25,91.11 120,90.85 120,90.48 120.27,90.2 120.27,89.35 120.46,89.16 v1(120.46,88.75) 120.27,88.56 120.27,88.19 120.34,88
  BOTTOM w0.102: 120.34,88 120.83,87.26 120.83,83.01 121.33,82.51 121.33,81.99 120.96,81.61 v2(120.74,81.61)
HDA_SYNC_R: length 155.5
  TOP w0.112: RC92.1 120.18,79.67 120.18,76.76 121.5,75.44 140.7,75.44 147.76,68.38 162.55,68.38 164.84,70.67 172.37,70.67 173.71,69.33 v1(174.56,69.33) 178.76,69.33 181.3,66.78 184.24,66.78 187.73,65.32 226.97,65.32 228.18,66.53 230.05,66.53 230.53,66.05 233.29,66.05 236.13,68.9 238.84,68.9 240.22,70.27 243.78,70.27 244.5,70.99 254.99,70.99 255.6,70.38 v2(255.6,69.81) ; UA1.10 255.93,63.92 255.51,64.34 v2(255.51,64.57)
  BOTTOM w0.119: v2(255.51,64.57) 256.06,65.11 256.06,67.33 255.6,67.79 v2(255.6,69.81)
HDD_DET#: length 15.9
  BOTTOM w0.076: 134.84,109.99 134.83,109.99 134.62,109.99 134.42,109.79 133.63,109.79 132.76,108.93 132.32,108.93 132.16,108.87 131.99,108.87 131.83,108.92 131.66,108.92 UC1.H2
  BOTTOM w0.112: 134.84,109.99 140.02,109.99 140.85,109.46 143.19,109.46 143.64,109.02 v1(144.78,109.02) 145.82,109.02 146.05,109.24 RPC4.1
HDMI_CEC: length 12.9
  IN3 w0.135: v2(12.6,91.64) 12.6,91.26 12.19,90.85 12.19,87.84 JHDMI1.13
  BOTTOM w0.112: RV19.1 19.91,91.64 v1(14.78,91.64) v2(12.6,91.64)
HDMI_CLKN: length 3
  TOP w0.112: RV17.1 19.09,84.78 19.62,84.78 v2(19.76,84.92)
  BOTTOM w0.112: CV38.1 20.18,84.92 v2(19.76,84.92) 19.62,84.78 19.25,84.78 19.1,84.93 LV12.1 18.77,85.09 LV38.1
HDMI_CLKP: length 3
  TOP w0.112: RV16.1 19.08,84.52 19.58,84.52 v2(19.76,84.34)
  BOTTOM w0.112: CV37.1 20.23,84.34 v2(19.76,84.34) 19.58,84.52 19.25,84.52 19.11,84.38 LV12.2 18.77,84.22 LV37.1
HDMI_CTRL_CLK: length 9.7
  TOP w0.112: QV3.6 17.48,90.11 17.22,89.85 RV22.1 16.69,89.75 15.7,89.75 14.44,91 12.6,91 12.11,90.52 12.11,88.5 11.72,88.1 JHDMI1.15
HDMI_CTRL_DATA: length 11.5
  TOP w0.107: QV3.3 19.41,88.04 18.95,87.58 17.74,87.58 17.55,87.77
  TOP w0.112: 17.55,87.77 17.36,87.96 17.36,88.42 RV23.1 16.79,88.99 16.27,89.51 15.6,89.51 14.34,90.77 12.7,90.77 12.35,90.42 12.35,88.81 12.56,88.6 JHDMI1.16
HDMI_HPD: length 15.9
  BOTTOM w0.102: v1(24.98,87.7) 24.14,88.54 RV21.1
  BOTTOM w0.112: JHDMI1.19 11.45,90.38 12.2,91.13 14.85,91.13 15.37,90.61 16.25,90.61 16.81,90.05 19.9,90.05 21.87,88.09 QV5.1 22.77,88.54 RV21.1
HDMI_L_CLKN: length 6
  BOTTOM w0.112: JHDMI1.12 13.37,86.23 14.12,86.23 v4(14.84,85.51) 15.56,84.8 16.41,84.8 RV35.1 17.05,84.79 17.39,84.79 17.53,84.93 LV12.4 17.85,85.09 LV38.2
HDMI_L_CLKP: length 6
  BOTTOM w0.112: LV37.2 17.85,84.22 LV12.3 17.53,84.38 17.39,84.52 17.05,84.52 RV35.2 16.39,84.53 v4(15.76,84.53) 15.45,84.53 14.01,85.97 13.37,85.97 JHDMI1.10
HDMI_L_TX_N0: length 14.4
  BOTTOM w0.112: JHDMI1.9 11.82,84.73 11.92,84.73 12.09,84.91 12.09,90.06 12.48,90.45 13.35,90.45 15.09,88.72 v4(15.09,88.28) 15.09,87.87 16.32,86.64 16.4,86.64 RV32.1 17.05,86.63 17.38,86.63 17.52,86.77 LV9.4 17.85,86.94 LV36.2
HDMI_L_TX_N1: length 8.5
  BOTTOM w0.112: JHDMI1.6 13.37,83.23 13.63,83.23 13.76,83.36 13.76,84.22 14.02,84.49 14.76,84.49 15.04,84.22 15.04,82.55 15.15,82.44 15.57,82.44 v4(15.8,82.66) 16.08,82.94 16.39,82.94 RV29.1 17.04,82.95 17.39,82.95 17.53,83.09 LV6.4 17.85,83.25 LV34.2
HDMI_L_TX_N2: length 10.4
  BOTTOM w0.112: JHDMI1.3 11.84,81.71 12.12,81.71 12.39,81.43 12.39,80.8 14.28,78.91 14.71,78.91 14.83,79.04 v4(14.83,79.45) 14.83,80.7 15.24,81.11 16.4,81.11 RV26.1 17.04,81.11 17.42,81.11 17.56,81.25 LV3.4 17.85,81.41 LV32.2
HDMI_L_TX_P0: length 14.4
  BOTTOM w0.112: JHDMI1.7 11.82,84.47 12.03,84.47 12.36,84.8 12.36,89.95 12.59,90.19 13.24,90.19 14.82,88.61 14.82,87.76 v4(15.64,86.95) 16.21,86.37 16.39,86.37 RV32.2 17.05,86.37 17.4,86.37 17.55,86.22 LV9.3 17.85,86.06 LV35.2
HDMI_L_TX_P1: length 8.5
  BOTTOM w0.112: JHDMI1.4 13.37,82.97 13.74,82.97 14.02,83.25 14.02,84.11 14.13,84.22 14.65,84.22 14.77,84.11 v4(14.77,83.56) 14.77,82.44 15.04,82.17 15.68,82.17 16.19,82.68 16.4,82.68 RV29.2 17.05,82.69 17.42,82.69 17.57,82.54 LV6.3 17.85,82.38 LV33.2
HDMI_L_TX_P2: length 10.4
  BOTTOM w0.112: JHDMI1.1 11.79,81.44 12.01,81.44 12.13,81.32 12.13,80.69 14.17,78.65 14.82,78.65 15.1,78.93 15.1,80.59 15.35,80.85 v4(15.66,80.85) 16.39,80.85 RV26.2 17.05,80.85 17.44,80.85 17.58,80.7 LV3.3 17.85,80.54 LV31.2
HDMI_TX_N0: length 3
  TOP w0.112: v2(19.76,86.76) 19.62,86.62 19.09,86.62 RV15.1
  BOTTOM w0.112: CV36.2 20.18,86.76 v2(19.76,86.76) 19.63,86.64 19.23,86.64 19.09,86.77 LV9.1 18.77,86.94 LV36.1
HDMI_TX_N1: length 3
  TOP w0.112: v2(19.76,83.08) 19.62,82.94 19.09,82.94 RV13.1
  BOTTOM w0.112: LV34.1 18.77,83.25 LV6.1 19.07,83.09 19.23,82.93 19.61,82.93 v2(19.76,83.08) 20.18,83.08 CV34.2
HDMI_TX_N2: length 3
  TOP w0.112: v2(19.76,81.24) 19.62,81.1 19.09,81.1 RV11.1
  BOTTOM w0.112: LV32.1 18.77,81.41 LV3.1 19.03,81.25 19.19,81.09 19.61,81.09 v2(19.76,81.24) 20.18,81.24 CV32.2
HDMI_TX_P0: length 3
  TOP w0.112: v2(19.76,86.18) 19.58,86.36 19.08,86.36 RV14.1
  BOTTOM w0.112: CV35.2 20.23,86.18 v2(19.76,86.18) 19.57,86.37 19.25,86.37 19.1,86.22 LV9.2 18.77,86.06 LV35.1
HDMI_TX_P1: length 3.1
  TOP w0.112: v2(19.76,82.5) 19.58,82.68 19.08,82.68 RV12.1
  BOTTOM w0.112: LV33.1 18.77,82.38 LV6.2 19.11,82.54 19.24,82.67 19.59,82.67 v2(19.76,82.5) 19.86,82.6 20.13,82.6 CV33.2
HDMI_TX_P2: length 3
  TOP w0.112: v2(19.76,80.66) 19.58,80.84 19.08,80.84 RV10.1
  BOTTOM w0.112: CV31.2 20.23,80.66 v2(19.76,80.66) 19.59,80.82 19.18,80.82 19.05,80.7 LV3.2 18.77,80.54 LV31.1
HOST_DEBUG_TX: length 101
  TOP w0.112: v2(239.78,98.91) 239.28,99.41 238.24,99.41 RZ132.1 237.63,99.11 v1(237.63,99.96) ; UE1.G11 v2(251.08,92.26)
  IN1 w0.119: v2(251.08,92.26) 251.08,92.49 251.51,92.91 251.51,93.41 251.05,93.86 251.05,95.77 251.31,96.02 251.31,98.36 250.66,99.01 250.66,100.02 251.62,100.99 v2(251.62,101.8) 251.62,108.2 250.67,109.15 250.67,113.24 252.68,115.26 252.68,122.38 258.71,128.41 286.41,128.41 290.48,124.34 v2(291.68,124.34)
  BOTTOM w0.112: RE73.2 RE306.2 288.83,122.77 289.58,122.77 289.64,122.84 JDEG1.8 291.36,122.84 291.68,123.16 v2(291.68,124.34) ; v2(239.78,98.91) 239.96,99.09 239.96,100.64 241.85,102.53 244.46,102.53 246.03,100.96 248.42,100.96 249.16,101.7 251.52,101.7 v2(251.62,101.8)
HOST_SD_WP#: length 207.5
  TOP w0.112: QR1.2 280.81,57.91 v2(280.69,58.02)
  IN1 w0.119: v2(260.89,73.02) 261.07,72.85 262.6,72.85 263.93,71.51 263.93,70.17 266.43,67.66 266.43,63.75 271.78,58.41 274.83,58.41 276.5,60.08 278,60.08 279.77,58.31 280.41,58.31 v2(280.69,58.02)
  IN2 w0.124: v2(135,98.45) 135,98.88 134.65,99.22 131.25,99.22 130.69,99.79 130.55,99.92 130.55,100.67 130.07,101.15 125.37,101.15 v2(124.76,101.76) ; v2(147.62,99.69) 147.81,99.5 149.63,99.5 150.98,98.16 150.98,92.91 153.79,90.1 163.07,90.1 166.2,86.97 166.2,84.38 168.57,82.01 168.57,79.04 169.36,78.25 169.36,73.06 170.34,72.07 175.25,72.07 179.57,67.75 183.86,67.75 185.64,65.97 203.83,65.97 205.18,64.63 226.54,64.63 227.91,66 230.03,66 230.6,65.43 235.78,65.43 238.67,68.32 240.53,68.32 242.52,70.31 243.04,70.31 243.59,70.86 244.9,70.86 245.5,71.46 248.98,71.46 249.61,72.09 252.22,72.09 252.87,72.75 256.21,72.75 256.57,73.11 258.05,73.11 258.14,73.02 v2(260.89,73.02)
  IN3 w0.135: v2(135,98.45) 135.06,98.5 140.98,98.5 142.22,99.75 144.18,99.75 145.11,100.68 145.71,100.68 146.36,100.03 147.28,100.03 v2(147.62,99.69)
  BOTTOM w0.076: UC1.W10 126.79,103.49 124.99,103.49 124.84,103.34 124.84,103.06 125.09,102.81 125.09,102.53 124.76,102.11 v2(124.76,101.76) ; v2(135,98.45) 135.31,98.75 135.55,98.75
  BOTTOM w0.112: RC292.1 138.89,98.75 135.55,98.75
HP_OUT_L: length 11.4
  TOP w0.203: UA1.32 257.93,56.05 v2(258.34,55.64)
  TOP w0.381: v2(258.34,55.64) RA7.1 ; CA43.2 v2(251.69,57.29)
  IN1 w0.381: v2(258.34,55.64) 257.83,55.64 257.58,55.38 253.59,55.38 v2(251.69,57.29)
  BOTTOM w0.127: v2(258.34,55.64) v1(258.34,54.87)
HP_OUT_R: length 12.3
  TOP w0.203: UA1.33 258.33,56.5 v1(258.76,56.06) 259.04,55.78
  TOP w0.381: CA44.2 v2(251.69,58.49) ; RA8.1 259.23,55.45 v2(259.04,55.64) 259.04,55.78
  IN1 w0.381: v2(251.69,58.49) 251.69,58.23 253.9,56.02 257.2,56.02 257.52,56.34 258.47,56.34 259.04,55.76 v2(259.04,55.64)
HV_GATE1_A: length 3
  TOP w0.076: 35.11,79.66 35.04,79.72 33.77,79.72 UT5.B9
  TOP w0.112: 35.11,79.66 RT64.1
HV_GATE2_A: length 2.9
  TOP w0.076: 35.11,79.2 34.84,79.47 UT5.A9
  TOP w0.112: 35.11,79.2 35.39,78.92 35.39,78.51 36.02,77.89 RT65.1
HW_GPS_DISABLE#: length 71.3
  TOP w0.107: v2(259.31,80.29) 259.59,80.29 RE12.1 ; UE1.H5 v2(252.68,86.66)
  TOP w0.112: DZ6.1 241.58,106.5 v1(241.58,107.39) v2(242.59,108.41)
  IN1 w0.119: v2(265.17,108.47) 264.11,107.41 264.11,99.29 263.41,98.59 263.41,96.49 262.72,95.79 262.72,86.1 262.24,85.62 262.24,81.13 261.57,80.45 259.47,80.45 v2(259.31,80.29)
  IN2 w0.124: v2(259.31,80.29) 258.41,81.19 258,81.19 254.53,84.66 253.84,84.66 253.67,84.49 252.47,84.49 252.2,84.77 252.2,86.17 v2(252.68,86.66)
  BOTTOM w0.112: v2(265.17,108.47) 258.79,108.47 258.66,108.6 254.6,108.6 253.99,107.99 251.2,107.99 250.6,108.6 242.78,108.6 v2(242.59,108.41)
HW_GPS_DISABLE#_R: length 3.5
  TOP w0.112: DZ6.2 239.74,105.48 v2(239.74,105.49) v1(239.74,106.55)
  BOTTOM w0.102: JNGFF2.18 239.66,105.5 v2(239.74,105.49)
I2C1_SCK_TP: length 143
  TOP w0.112: RZ29.1 215.85,55.8 RZ21.2 215.54,54.63 215.54,54.17 215.27,53.91 215.27,52.97 214.93,52.63 213.79,52.63 213.17,53.25 207.05,53.25 206.52,53.79 205.45,53.79 203.35,55.88 203.35,56.9 202.27,57.98 202.27,59.78 201.04,61.01 186.48,61.01 183.59,63.91 180.96,63.91 179.97,62.92 v2(179.97,62.63)
  IN1 w0.102: 130.64,105.43 128.23,105.43 127.66,104.86 v2(127.51,104.86)
  IN1 w0.119: 130.64,105.43 131.35,105.43 132.89,106.97 138.54,106.97 140.2,108.63 147.79,108.63 150.93,105.48 150.93,103.68 151.77,102.84 151.77,102.36 152.23,101.91 152.23,101.02 152.09,100.88 152.09,96.01 153.08,95.03 153.08,90.88 151.67,89.47 151.67,84.15 150.39,82.87 150.39,71.71 151.61,70.49 163.42,70.49 163.93,71 171.67,71 175.02,67.64 176.46,67.64 179.81,64.3 179.81,62.8 v2(179.97,62.63)
  BOTTOM w0.076: v2(127.51,104.86) 127.51,104.5 UC1.U9
I2C1_SCK_TP_R: length 6.6
  TOP w0.112: v2(213.84,59.83) 213.88,59.79 213.88,58.16 214.25,57.8 v1(214.81,57.8) 215.66,57.8 RZ347.2 215.85,56.74 RZ29.2 RZ117.2
  BOTTOM w0.112: v2(213.84,59.83) 213.55,59.54 JKBTP1.2
I2C1_SDA_TP: length 142
  TOP w0.112: v2(179.39,62.63) 179.39,62.63 179.74,62.98 179.74,63.02 180.86,64.15 183.69,64.15 186.58,61.25 201.14,61.25 202.51,59.88 202.51,58.08 203.59,57 203.59,55.98 205.55,54.02 206.62,54.02 207.15,53.49 213.27,53.49 213.89,52.87 214.83,52.87 215.04,53.07 215.04,54.01 215.3,54.27 215.3,54.63 RZ20.2 214.98,55.8 RZ26.1
  IN1 w0.102: v2(128.22,104.84) 128.61,105.23 130.6,105.23 130.64,105.18
  IN1 w0.119: v2(179.39,62.63) 179.56,62.8 179.56,64.19 176.36,67.4 174.92,67.4 171.56,70.75 164.03,70.75 163.52,70.24 151.51,70.24 150.15,71.6 150.15,82.97 151.42,84.25 151.42,89.57 152.83,90.99 152.83,94.92 151.85,95.91 151.85,100.98 151.98,101.12 151.98,101.81 151.53,102.26 151.53,102.74 150.69,103.57 150.69,105.38 147.69,108.38 140.3,108.38 138.64,106.72 132.99,106.72 131.45,105.18 130.64,105.18
  BOTTOM w0.076: v2(128.22,104.84) 128.39,104.67 UC1.U8
I2C1_SDA_TP_R: length 5.8
  TOP w0.112: RZ26.2 RZ116.2 RZ346.2 213.19,57.2 213.3,57.3 v1(213.3,57.96) 213.3,59.75 v2(213.23,59.82)
  BOTTOM w0.112: v2(213.23,59.82) 213.05,59.63 JKBTP1.3
I_ADP: length 239.3
  TOP w0.107: UE1.B11 v2(247.08,92.26)
  TOP w0.112: v2(63.18,57.66) 63.63,57.21 63.63,55.33 62.51,54.21 61.77,54.21 61.49,53.94 v1(61.49,52.54) 61.49,52.18 59.82,50.51 57.74,50.51 PR935.2
  IN2 w0.124: v2(247.08,92.26) 245.34,90.51 239.56,90.51 237.04,88 237.04,86.89 235.68,85.52 235.68,81.32 236.17,80.83 v2(236.61,80.83) ; v2(63.18,57.66) 63.34,57.83 69.36,57.83 69.8,57.39 71.69,57.39 75.74,53.34 102.77,53.34 103.89,54.46 140.16,54.46 141.71,55.64 144.6,55.64 146.07,57.1 159.32,57.1 161.53,54.89 177.71,54.89 179.8,52.8 184.44,52.8 185.77,51.46 196.98,51.46 198.04,52.52 201.55,52.52 202.58,51.5 206.37,51.5 207.11,52.23 209.32,52.23 210.06,52.97 213.83,52.97 214.31,52.49 218.42,52.49 219.5,53.57 225.6,53.57 226.11,53.06 229.63,53.06 229.73,52.96 230.85,52.96 v2(230.93,53.04)
  BOTTOM w0.112: v2(230.93,53.04) 231.32,53.42 231.32,53.57 233.48,55.73 233.48,56.96 236.22,59.71 236.22,62.46 235.89,62.79 235.89,65.34 235.38,65.85 235.38,67.35 235.26,67.46 235.26,69.92 235.62,70.28 235.62,79.55 236.61,80.53 v2(236.61,80.83)
I_BATT: length 231.9
  TOP w0.107: v2(256.49,76.08) 256.63,76.22 256.63,78 256.12,78.51 RE64.2
  IN2 w0.124: v2(238.05,56.55) 238.05,55.8 234.47,52.22 229.83,52.22 229.44,52.61 225.93,52.61 225.41,53.12 219.76,53.12 218.66,52.02 214.15,52.02 213.64,52.52 210.28,52.52 208.77,51.01 184.57,51.01 183.24,52.35 179.61,52.35 177.52,54.44 161.35,54.44 159.14,56.65 146.35,56.65 144.83,55.13 141.87,55.13 140.34,53.97 104.12,53.97 103.02,52.88 75.56,52.88 71.53,56.91 69.64,56.91 69.19,57.36 65.75,57.36 65.12,56.73 64.79,56.73 v2(64.37,57.15)
  IN3 w0.135: v2(256.49,76.08) 256.46,76.06 256.46,74.81 256.06,74.41 254.94,74.41 253.86,73.33 252.92,73.33 247.52,67.93 247.52,66.58 245.67,64.73 245.67,62.99 244.83,62.15 244.83,61.3 241.25,57.73 238.71,57.73 238.05,57.07 v2(238.05,56.55)
  BOTTOM w0.112: v2(64.37,57.15) 64.49,57.03 64.49,54.62 62.35,52.48 62.35,50.56 61.72,49.93 57.53,49.93 57.16,50.3 v1(57.16,51.05) 57.05,51.17 57.05,51.6 57.5,52.06 PR947.2
I_BATT_R: length 8
  TOP w0.102: UE1.J4 v2(253.48,85.86)
  TOP w0.112: RE64.1 256.11,79.92 CE3.1 256.11,81.28 v2(255.98,81.41)
  IN1 w0.119: v2(253.48,85.86) 253.88,85.46 254.51,85.46 254.68,85.28 254.68,83.93 255.98,82.64 v2(255.98,81.41)
I_SYS: length 281.1
  TOP w0.112: v2(47.08,56.14) 47.08,57.92 v1(43.42,61.58) 42.7,61.58 38.44,65.84 38.44,75.99 40.38,77.93 40.38,79.73 44.44,83.79 44.44,87.8 45.17,88.53 46.26,88.53 PR620.1 ; v2(63.18,57.06) 63.18,55.29 62.36,54.47 61.62,54.47 61.14,53.99 61.14,52.16 59.8,50.82 58.23,50.82 57.61,51.45 v2(57.49,51.45) PR936.2 ; v2(257.07,76.08) 257.26,76.27 RE312.2
  IN2 w0.124: v2(63.18,57.06) 63.74,56.5 65.21,56.5 65.85,57.13 69.09,57.13 70.73,55.49 72.63,55.49 76.13,51.99 102.45,51.99 104.21,53.75 140.44,53.75 141.94,54.87 144.96,54.87 146.51,56.42 159.04,56.42 161.25,54.21 177.43,54.21 179.52,52.12 183.14,52.12 184.48,50.79 208.9,50.79 210.41,52.29 213.55,52.29 214.05,51.79 218.79,51.79 219.86,52.87 225.34,52.87 225.83,52.38 229.35,52.38 229.76,51.97 234.57,51.97 238.64,56.03 v2(238.64,56.55)
  IN3 w0.135: v2(47.08,56.14) 47.08,55.9 47.71,55.27 48.75,55.27 51.66,52.36 56.58,52.36 v2(57.49,51.45) ; v2(238.64,56.55) 238.64,57.03 238.98,57.37 241.23,57.37 245.06,61.21 245.06,62.05 245.92,62.91 245.92,64.6 247.78,66.46 247.78,67.85 252.99,73.07 253.98,73.07 255.02,74.1 256.28,74.1 257.07,74.89 v2(257.07,76.08)
I_SYS_R: length 13.6
  TOP w0.107: UE1.J5 v2(253.48,86.66)
  TOP w0.112: v1(258.32,77.04) 257.73,77.62 RE312.1 257.26,78.38 RE313.1 CE4.1 257.02,79.78 v2(257.39,80.15)
  IN1 w0.119: v2(257.39,80.15) 257.39,81.74 255.61,83.51 255.61,85.99 255.34,86.26 253.88,86.26 v2(253.48,86.66)
ILIM_SEL: length 2.9
  TOP w0.112: UI3.4 276.01,77.62 275.92,77.71 275.58,77.71 275.3,77.99 RI13.1 v1(274.36,78.74)
ILMT_+1VALWP: length 3.8
  TOP w0.112: v1(157.26,87.34) 156.97,87.04 PR310.1
  TOP w0.254: PR310.1 PR307.2 156.18,85.86 v2(155.88,85.56)
  BOTTOM w0.254: v2(155.88,85.56) 155.88,85.23 155.63,84.98 PU301.3
ILMT_DDR: length 3.9
  BOTTOM w0.112: PR207.2 v3(62.58,71.65)
  BOTTOM w0.254: PU200.17 65.91,71.11 65.68,71.33 65.67,71.33 65.56,71.45 64.62,71.45 PR205.1 PR207.2
IMON_IA: length 4.7
  TOP w0.203: PU602.14 53.08,93.57 53.34,93.31 v2(53.54,93.31)
  BOTTOM w0.112: v2(53.54,93.31) 53.86,93.31 v1(54.82,94.27)
  BOTTOM w0.203: PR629.2 52.06,93.69 PC625.2 53.16,93.69 v2(53.54,93.31)
IMON_VSA: length 3.6
  TOP w0.203: v2(51.59,97.88) 51.59,97.72 51.14,97.27 PU602.23
  BOTTOM w0.112: v2(51.59,97.88) 51.59,98.08 v1(51.84,98.33)
  BOTTOM w0.203: v2(51.59,97.88) 51.59,97.43 PC643.1 PR651.1
IMVP_VR_ON: length 323.3
  TOP w0.112: RE304.1 267,99.45 267.52,98.93 v2(267.52,98.16) 268.08,97.6 UE3.4 268.58,97.67 270.34,97.67 270.53,97.48 UE4.2 ; v2(43.25,61.07) 42.75,61.07 38.06,65.76 v1(38.06,66.5) 38.06,75.99 40.13,78.06 40.13,79.95 44.18,84.01 44.18,88.16 45.55,89.53 45.55,89.85 PR616.1
  IN2 w0.124: v2(267.52,98.16) 268.58,98.16 272.07,94.66 272.07,92.5 266.71,87.14 266.71,84.56 267.76,83.51 267.76,80.15 271.05,76.86 271.05,69.53 269.05,67.53 263.35,67.53 261.11,65.29 256.59,65.29 256.28,64.98 253.16,64.98 252.12,63.94 249.78,63.94 245.87,60.03 245.87,59.2 243.19,56.52 242.46,56.52 240.17,54.22 240.17,53.44 238.02,51.29 229.04,51.29 228.77,51.02 213.81,51.02 213.21,51.62 210.72,51.62 209.21,50.11 184.17,50.11 182.87,51.4 179.66,51.4 179.32,51.06 178.41,51.06 175.94,53.53 160.96,53.53 158.74,55.75 147.89,55.75 146.27,54.13 142.19,54.13 140.72,53.02 115.07,53.02 113.36,51.31 74.89,51.31 71.39,54.82 70.34,54.82 69.36,55.8 61.78,55.8 60.19,54.21 59.48,54.21 58.58,55.1 53.2,55.1 50.81,57.49 47.46,57.49 44.99,59.95 43.65,59.95 43.25,60.35 v2(43.25,61.07)
IMVP_VR_ON_EC: length 24.6
  TOP w0.107: UE1.N7 257.61,88.66 v2(258.01,88.25)
  TOP w0.112: v2(258.47,97.8) 259.18,98.52 RPE10.2 ; v2(265.45,99.54) 265.48,99.54 265.96,100.02 RE304.2 266.09,98.99 266.19,98.9 UE3.1
  IN1 w0.119: v2(258.47,97.8) 258.47,96.85 257.52,95.9 257.52,92.61 258.42,91.7 258.42,88.66 v2(258.01,88.25)
  IN3 w0.135: v2(258.47,97.8) 258.92,97.8 261.28,100.16 262.46,100.16 263.08,99.54 v2(265.45,99.54)
INT_SPK_L+: length 43.2
  TOP w1.016: 278.82,24.17 277.33,25.66 277.33,46.75 275.23,48.84 275.23,52.08 266.85,60.46 264.95,60.46
  vias: v1(263.32,60.62)
INT_SPK_L-: length 42.7
  TOP w1.016: 264.95,61.61 267.32,61.61 276.38,52.55 276.38,49.32 278.47,47.22 278.47,26.55 278.92,26.11
  vias: v1(264.08,61.91)
INT_SPK_R+: length 47.5
  IN1 w1.016: 263.47,62.19 266.46,62.19 278.47,50.18 278.47,22.68
  vias: v1(261.49,61.71) v2(261.87,62.06) v2(262.48,62.06) v2(279.11,21.47) v2(279.74,21.47)
INT_SPK_R-: length 48.7
  IN1 w1.016: 278.66,20.39 277.33,21.73 277.33,49.7 266.03,61 263.14,61
  vias: v1(279.86,19.7) v2(261.69,61.15) v2(262.28,61.3) v2(278.64,19.44) v2(279.23,19.44)
INT_SPKR_L+: length 6.8
  TOP w0.102: 281.46,22.64 v3(281.99,22.64)
  BOTTOM w0.762: JSPK1.1 286.02,21.1 284.31,22.81 282.38,22.81
  vias: v2(281.25,23.01) v2(281.25,22.43)
INT_SPKR_L-: length 12.6
  TOP w0.102: 281.41,24.8 v3(282.07,24.8)
  BOTTOM w0.762: 282.38,24.71 284.57,24.71 288,21.28 288,18.62 287.28,17.9 JSPK1.2
  vias: v2(281.25,25.07) v2(281.25,24.48)
INT_SPKR_R+: length 7.4
  TOP w0.102: 281.46,20.71 v3(281.96,20.71)
  BOTTOM w0.762: JSPK1.3 284.91,16.65 284.28,17.28 284.28,19.84 283.34,20.79 DA7.2
  vias: v2(281.25,20.97) v2(281.25,20.38)
INT_SPKR_R-: length 6.4
  TOP w0.102: 281.43,18.65 v3(281.86,18.65)
  BOTTOM w0.762: DA7.3 282.7,18.86 283.23,18.33 283.23,16.85 284.69,15.4 JSPK1.4
  vias: v2(281.25,18.93) v2(281.25,18.35)
INTRUDER#: length 15.7
  TOP w0.112: RC69.1 127.42,83.91 127.99,84.48 v1(127.99,88.06) 127.99,89.42 125.67,91.74 124.24,91.74 123.05,92.94 123.05,93.28 123.27,93.5 123.27,94.43 123.16,94.54 123.16,95.04 v2(122.92,95.28)
  BOTTOM w0.102: UC1.AP16 122.92,95.36 122.92,95.28 v2(122.92,95.28)
IR_CAM_DET#: length 183
  TOP w0.112: v2(153.91,107.25) 153.91,107.64 154.72,108.45 154.72,113.5 155.44,114.22 155.44,117.45 v1(157.81,119.82) 158.73,120.74 v2(160.02,120.74)
  IN1 w0.119: v2(39.33,132.9) 39.33,130.67 41.34,128.66 45.31,128.66 49.35,132.7 73.69,132.7 76.78,129.61 79.07,129.61 83.14,133.68 107.14,133.68 108.81,132 117.02,132 125.35,123.68 130.21,123.68 131.4,122.48 132.11,122.48 133.6,123.97 139.3,123.97 139.47,124.13 146.03,124.13 146.44,123.72 158.35,123.72 160.02,122.05 v2(160.02,120.74)
  BOTTOM w0.076: UC1.H5 130.23,108.16 132.06,108.16 132.21,108.06 133.91,108.06 134.14,107.83 135.16,107.83 RC345.1 136.37,109.04 136.75,109.04
  BOTTOM w0.112: JIR1.6 v2(39.33,132.9) ; 136.75,109.04 139.96,109.04 140.79,108.62 142.35,108.62 143.92,107.06 143.92,104.9 144.63,104.18 145.82,104.18 146.25,104.62 149.9,104.62 152.53,107.25 v2(153.91,107.25)
ISH_I2C2_SCL: length 197.3
  TOP w0.112: v2(153.1,96.05) 153.15,96.09 153.15,96.25 152.74,96.66 149.11,96.66 148.63,96.18 148.34,96.18 147.9,95.73 147.2,95.73 146.76,96.17 146.76,97.61 145.62,98.75 144.82,98.75 143.55,97.49 142.79,97.49 v2(142.62,97.32) ; RZ76.1 241.33,101.87 241.58,101.87 241.83,101.62 241.83,100.34 241.56,100.08 239.24,100.08 v2(239.07,99.9)
  IN1 w0.119: v2(142.62,97.32) 142.45,97.49 140.52,97.49 136.8,101.2 135.61,101.2 135.04,101.77 132.06,101.77 131.34,101.05 126.81,101.05 v2(126.13,101.73)
  IN3 w0.135: v2(239.07,99.9) 238.89,100.08 238.59,100.08 237.5,98.99 237.5,98.7 234.42,95.62 234.42,79.95 236.48,77.89 238.03,77.89 239.83,76.1 239.83,70.61 237.66,68.44 236.28,68.44 236,68.16 235.37,68.16 232.53,65.32 229.03,65.32 225.13,61.43 217.38,61.43 217.07,61.12 214.36,61.12 213.73,61.74 202.77,61.74 201.92,62.59 196.29,62.59 194.94,62.6 arc(186.99,63.68) 179.63,66.85 178.85,67.32 163.99,67.32 160.37,70.95 152.17,70.95 149.99,73.13 149.99,82.54 151.99,84.55 151.99,86.64 153.78,88.43 153.78,91.62 153.28,92.12 153.28,95.87 v2(153.1,96.05)
  BOTTOM w0.102: UC1.AD12 125.78,101.38 v2(126.13,101.73)
  BOTTOM w0.112: RC362.1 142.22,97.49 142.44,97.49 v2(142.62,97.32)
ISH_I2C2_SCL_R: length 2.4
  TOP w0.112: v2(239.1,102.06) 239.3,101.85 239.75,101.85 RZ76.2
  BOTTOM w0.102: v2(239.1,102.06) 239.05,102 JNGFF2.32
ISH_I2C2_SDA: length 195.9
  TOP w0.112: v2(142.62,97.9) 142.79,97.73 143.45,97.73 144.72,98.99 145.72,98.99 147,97.71 147,96.27 147.29,95.97 147.8,95.97 148.25,96.42 148.53,96.42 149.01,96.9 152.84,96.9 v2(153.69,96.05) ; v2(239.07,100.49) 239.24,100.32 241.46,100.32 241.59,100.44 241.59,101.52 241.48,101.63 241.33,101.63 RZ77.1
  IN1 w0.119: v2(126.77,101.73) 126.77,101.54 127.01,101.3 131.23,101.3 131.95,102.02 135.14,102.02 135.71,101.45 136.91,101.45 140.62,97.73 142.45,97.73 v2(142.62,97.9)
  IN3 w0.135: v2(153.69,96.05) 153.54,95.9 153.54,92.23 154.04,91.73 154.04,88.32 152.25,86.53 152.25,84.44 150.25,82.43 150.25,73.24 152.28,71.21 160.47,71.21 164.1,67.58 178.92,67.58 179.76,67.08 arc(187.06,63.94) 194.94,62.86 196.29,62.86 202.03,62.86 202.88,62 213.84,62 214.46,61.38 216.96,61.38 217.27,61.69 225.03,61.69 228.92,65.58 232.42,65.58 235.26,68.42 235.89,68.42 236.17,68.7 237.55,68.7 239.57,70.72 239.57,75.99 237.93,77.63 236.37,77.63 234.16,79.84 234.16,95.73 237.24,98.81 237.24,99.1 238.48,100.34 238.92,100.34 v2(239.07,100.49)
  BOTTOM w0.102: UC1.AD11 126.43,101.39 v2(126.77,101.73)
  BOTTOM w0.112: v2(142.62,97.9) 142.44,97.73 142.22,97.73 RC363.1
ISH_I2C2_SDA_R: length 2.4
  TOP w0.112: v2(239.1,101.42) 239.32,101.64 239.76,101.64 RZ77.2
  BOTTOM w0.102: v2(239.1,101.42) 239.02,101.5 JNGFF2.34
ISH_UART0_CTS#: length 147.2
  TOP w0.112: RZ80.1 v1(236.35,64.07) 235.48,63.21 185.36,63.21 183.97,64.6 180.01,64.6 179.13,63.73 v2(177.98,63.73)
  IN1 w0.119: v2(137.51,105.78) 140,105.78 141.14,104.64 146.61,104.64 149.5,101.75 149.5,100.1 150.18,99.42 150.18,93.89 148.84,92.55 148.84,85.1 148.47,84.73 148.47,70.88 151.04,68.31 163.17,68.31 164.67,66.81 172.03,66.81 175.11,63.73 v2(177.98,63.73)
  BOTTOM w0.076: UC1.U4 130.73,104.23 131.65,104.23 131.77,104.11 132.14,104.11 132.15,104.11 132.46,104.02 132.89,104.02 133.02,104.15 134.97,104.15 135.89,105.07 136.8,105.07 136.85,105.11
  BOTTOM w0.112: 136.85,105.11 v2(137.51,105.78)
ISH_UART0_CTS#_R: length 2.9
  TOP w0.112: RZ80.2 238.73,64.91 239.21,64.91 v2(239.22,64.9)
  BOTTOM w0.112: v2(239.22,64.9) 239.22,64.91 239.62,65.31 240.14,65.31 240.23,65.4 JNGFF1.62
ISH_UART0_RTS#: length 151.3
  TOP w0.112: v2(177.54,64.4) 177.54,63.49 177.72,63.31 179.05,63.31 180.12,64.37 183.82,64.37 186.53,61.66 v1(203.27,61.66) 204.07,62.46 211.97,62.46 212.4,62.03 216.98,62.03 217.93,62.98 236.14,62.98 RZ81.1
  IN1 w0.119: v2(140.53,106.74) 140.53,107.26 140.99,107.72 143.12,107.72 143.89,106.95 145.01,106.95 146.2,105.76 147.57,105.76 150.52,102.8 150.52,100.53 151.18,99.87 151.18,95.64 151.28,95.54 151.28,91.34 149.88,89.95 149.88,84.19 149.48,83.78 149.48,71.33 151.33,69.48 163.85,69.48 164.42,70.04 171.15,70.04 174.6,66.58 175.88,66.58 177.54,64.92 v2(177.54,64.4)
  BOTTOM w0.076: 132.71,104.84 131.46,104.84 UC1.U3
  BOTTOM w0.102: v2(140.53,106.74) 140.17,106.37 136.08,106.37 134.69,104.98 132.85,104.98 132.71,104.84
ISH_UART0_RTS#_R: length 2.8
  TOP w0.112: RZ81.2 238.51,64.44 v1(239.48,64.44) 239.8,64.75 v2(239.8,64.9)
  BOTTOM w0.112: JNGFF1.64 v2(239.8,64.9)
ISH_UART0_RXD: length 148.3
  TOP w0.112: v2(178.74,64.43) 179.42,65.11 184.17,65.11 185.44,63.84 v1(226.08,63.84) 227.59,63.84 228.79,65.05 229.44,65.05 229.92,64.57 235.07,64.57 RZ78.1
  IN1 w0.119: v2(136.35,105.78) 136.35,105.8 137.01,106.47 138.7,106.47 140.39,108.16 143.3,108.16 144.05,107.41 145.23,107.41 146.43,106.2 147.75,106.2 150.96,102.99 150.96,100.71 151.62,100.05 151.62,95.82 151.72,95.73 151.72,90.18 151.15,89.62 151.15,84.39 149.92,83.16 149.92,71.51 151.5,69.94 163.63,69.94 164.17,70.48 171.4,70.48 174.81,67.08 176.22,67.08 178.74,64.56 v2(178.74,64.43)
  BOTTOM w0.076: UC1.U1 132.77,104.5
  BOTTOM w0.102: 132.77,104.5 133.04,104.77 134.88,104.77 135.89,105.78 v2(136.35,105.78)
ISH_UART0_RXD_R: length 3.5
  TOP w0.112: v2(239.21,66.01) 239.21,66.58 238.78,67 RZ78.2
  BOTTOM w0.112: v2(239.21,66.01) 239.65,66.46 240,66.46 240.06,66.4 JNGFF1.58
ISH_UART0_TXD: length 148.8
  TOP w0.112: v2(178.15,64.43) 178.59,63.99 179.06,63.99 179.92,64.86 184.05,64.86 185.47,63.43 233.5,63.43 v1(233.84,63.78) 234.16,64.09 235.48,64.09 RZ79.1
  IN1 w0.119: v2(136.93,105.78) 136.93,105.83 137.31,106.21 138.75,106.21 140.48,107.94 143.21,107.94 143.96,107.19 145.13,107.19 146.35,105.98 147.66,105.98 150.74,102.9 150.74,100.62 151.4,99.96 151.4,95.73 151.5,95.63 151.5,90.28 150.93,89.71 150.93,84.52 149.7,83.29 149.7,71.42 151.42,69.71 163.75,69.71 164.31,70.26 171.27,70.26 174.71,66.83 175.98,66.83 178.15,64.66 v2(178.15,64.43)
  BOTTOM w0.076: 132.76,104.21 132.4,104.21 132.2,104.27 132.17,104.28 131.99,104.28 UC1.U2
  BOTTOM w0.102: v2(136.93,105.78) 136.52,105.37 135.79,105.37 134.96,104.54 133.09,104.54 132.76,104.21
ISH_UART0_TXD_R: length 3.2
  TOP w0.112: RZ79.2 238.42,66.04 238.96,65.49 239.5,65.49 239.8,65.8 v2(239.8,66.01)
  BOTTOM w0.112: JNGFF1.60 239.91,65.9 v2(239.8,66.01)
ISUMN_GT: length 27.8
  TOP w0.254: v2(54.32,90.31) 53.82,89.81 PR638.1 PR632.1 ; v2(66.45,95.9) PR633.2
  IN1 w0.254: v2(55.9,92.09) 55.9,92.85 58.83,95.77 61.29,95.77 61.72,95.35 65.41,95.35 65.96,95.9 v2(66.45,95.9)
  IN3 w0.254: v2(55.9,92.09) 55.9,91.39 v1(54.82,90.31) v2(54.32,90.31)
  BOTTOM w0.112: v2(54.32,90.31) v1(54.82,90.31)
  BOTTOM w0.203: v2(54.32,90.31) 54.06,90.56 PC641.1 53.25,89.7 PC624.2 PC626.2
  BOTTOM w0.254: PH602.2 66.45,94.64 v2(66.45,95.9) 66.45,98.56 66.76,98.88 PL612.2
ISUMN_IA: length 34.2
  TOP w0.203: PC645.1 57.16,97.23 PR640.2 PR644.2 56.3,98.74 56.02,99.02 54,99.02 53.75,98.77 v2(53.75,97.31)
  TOP w0.254: PR656.2 65.43,104.74 v2(65.43,104.48)
  IN1 w0.254: v2(53.75,97.31) 54.7,98.26 54.7,99.08 60.04,104.43 63.73,104.43 64.24,104.94 64.97,104.94 v2(65.43,104.48)
  BOTTOM w0.112: PC642.2 55.4,98.25 v1(55.33,98.31)
  BOTTOM w0.203: PC642.2 PC646.2 v2(53.75,97.31)
  BOTTOM w0.254: PL610.2 65.81,107.39 65.43,107.01 v2(65.43,104.48) 66.08,103.83 67.02,103.83 67.35,103.5 PH605.2
ISUMN_VSA: length 50.2
  TOP w0.203: PC637.2 PC633.2 ; PC637.2 48.49,100.62 v2(48.77,100.91) ; PC637.2 PC644.1
  TOP w0.254: PR643.1 72.67,116.79 v1(72.88,116.58) 73.11,116.34 v2(73.11,115.71)
  IN1 w0.254: v2(48.77,100.91) 48.89,101.03 48.89,102.42 49.6,103.13 49.6,107.1 52.39,109.88 52.39,113.1 54.05,114.77 57.81,114.77 58.01,114.97 59.61,114.97 63.14,118.5 65.71,118.5 65.96,118.25 68.63,118.25 69,117.88 70.38,117.88 70.9,117.36 72.62,117.36 73.11,116.86 v2(73.11,115.71)
  BOTTOM w0.203: v2(48.77,100.91) 48.98,100.69 PR636.2 48.12,100.29 PR641.2
  BOTTOM w0.254: PL614.2 73.24,115.58 v2(73.11,115.71) 73.11,116.99 72.67,117.44 PH604.2
ISUMP_GT: length 25.4
  TOP w0.203: PU602.7 50.73,91.13 v2(51.45,90.42)
  TOP w0.254: PR628.1 PR633.1 65.31,97.5 PR674.1 v2(65.3,96.81)
  IN1 w0.254: v2(55.32,92.09) 55.32,92.89 58.58,96.15 61.45,96.15 61.83,95.77 65.05,95.77 65.3,96.02 v2(65.3,96.81)
  BOTTOM w0.254: v2(55.32,92.09) 55.32,89.66 v1(54.43,88.77) PC624.1 PC626.1 52.17,88.77 51.78,89.16 51.78,90.18 51.54,90.42 v2(51.45,90.42)
ISUMP_IA: length 23.7
  TOP w0.203: v2(53.41,96.35) 53.41,95.9 53.09,95.57 PU602.19
  TOP w0.254: v2(64.65,104.4) 64.65,104.6 PR656.1 63.52,105.73 PR661.2
  IN1 w0.254: v2(64.65,104.4) 64.1,103.85 60.29,103.85 55.35,98.91 55.35,98.14 53.57,96.35 v2(53.41,96.35)
  BOTTOM w0.112: PC642.1 56.46,96.39 v1(56.86,96.78)
  BOTTOM w0.203: PC642.1 PC646.1 53.45,96.39 v2(53.41,96.35)
  BOTTOM w0.254: PR657.1 v2(64.65,104.4)
ISUMP_VSA: length 42.4
  TOP w0.203: PU602.27 49.53,98.51 49.4,98.64 PC633.1 PC637.1 v2(49.4,100.91)
  TOP w0.254: PR624.2 70,116.2 70.24,116.45 PR643.2 69.85,117.18 v2(69.56,117.18)
  IN1 w0.254: v2(49.4,100.91) 49.27,101.04 49.27,102.27 49.99,102.98 49.99,106.94 52.78,109.74 52.78,112.87 54.29,114.38 57.96,114.38 58.16,114.59 59.8,114.59 63.33,118.12 65.45,118.12 65.73,117.84 68.5,117.84 69.16,117.18 v2(69.56,117.18)
  BOTTOM w0.254: v2(69.56,117.18) 69.56,117.84 v1(69.61,117.89) 69.68,117.97 70.81,117.97 PR642.1
ITP_PMODE: length 69.6
  TOP w0.112: RC115.1 89.06,133.17 v2(90.01,132.22)
  BOTTOM w0.076: UC1.E8 127.93,110.64 127.45,111.11 127.45,112.45 127.26,112.64 127.02,112.64 126.81,112.84 126.81,113.92 128.59,115.7 128.59,116.99
  BOTTOM w0.112: v2(90.01,132.22) JXDP1.46 90.01,134.26 90.72,134.96 123.8,134.96 124.74,134.02 125.63,134.02 126.21,133.44 126.21,131.74 126.57,131.38 v1(126.57,130.21) 126.57,129.45 123.29,126.17 123.29,120.34 125.79,117.83 127.75,117.83 128.59,116.99
JDIMM1_EVENT#: length 2.7
  TOP w0.112: v1(109.19,51.98) 109.48,52.26 v2(109.48,52.46) 109.76,52.75 RD14.1
  BOTTOM w0.112: v2(109.48,52.46) 109.48,52.46 JDIMM1.134
JTAG_CLK: length 83.8
  TOP w0.112: UE1.C8 v2(247.88,89.86)
  IN1 w0.119: v2(247.88,89.86) 247.48,90.26 247.48,94.16 247.62,94.3 247.62,95.03 247.08,95.57 247.08,98.58 247.44,98.93 247.44,104.19 248.82,105.57 248.82,113.86 250.72,115.76 251.41,115.76 251.68,116.03 251.68,122.94 258.16,129.42 287.27,129.42 v2(287.69,129) 289.09,127.61 289.43,127.61 291.68,125.36 v2(291.68,124.98)
  BOTTOM w0.112: v2(291.68,124.98) 291.54,124.84 JDEG1.4 289.98,124.84 289.94,124.88 289.52,124.88 289.5,124.86 RPE7.3
JTAG_RST#: length 12.3
  TOP w0.112: UE1.G13 251.48,94.73 250.95,95.26 250.95,96.07 250.13,96.89 249.55,96.89 249.41,97.03 249.41,99.13 249.63,99.35 RE63.1 249.16,99.77 249.1,99.71 JTAG1.1 248.54,100.89 CE30.1 RE65.1 248.69,102.42 v1(248.14,102.97)
JTAG_TDI: length 79.6
  TOP w0.112: v2(289.74,125.84) 287.85,125.84 v3(287.7,125.98) ; UE1.E9 v2(249.48,90.66)
  IN1 w0.119: v2(289.74,125.84) 286.92,128.66 258.58,128.66 252.43,122.51 252.43,115.36 250.26,113.19 250.26,105.97 248.16,103.86 248.16,97.03 248.85,96.34 248.85,95.6 249.09,95.36 249.09,91.05 v2(249.48,90.66)
  BOTTOM w0.112: RPE7.1 289.72,125.86 v2(289.74,125.84) JDEG1.2
JTAG_TDO: length 82.5
  TOP w0.107: UE1.F6 v2(250.28,87.46)
  TOP w0.112: v3(288.76,122.56) 289.38,123.19 289.38,124.05 v2(289.75,124.42)
  IN1 w0.119: v2(250.28,87.46) 250.28,88.04 251.97,89.72 251.97,92.52 252.22,92.77 252.22,96.35 252.68,96.81 252.68,98.64 252.37,98.94 252.37,108.39 251.69,109.08 251.69,109.97 252.17,110.45 252.17,111.67 251.84,112 251.84,113.17 252.3,113.63 252.3,114.16 252.94,114.8 252.94,122.26 258.84,128.15 286.02,128.15 v2(289.75,124.42)
  BOTTOM w0.112: RPE7.4 289.69,124.36 v2(289.75,124.42) 290.19,124.42 290.27,124.34 JDEG1.5
JTAG_TMS: length 85.7
  TOP w0.107: v2(247.88,86.66) 247.88,86.67 247.9,86.67 UE1.C5
  TOP w0.112: v3(288.72,124.47) 289.59,125.34 v2(290.08,125.34)
  IN1 w0.119: v2(247.88,86.66) UE1.C5 248.28,93.74 248.57,94.03 248.57,95.29 247.58,96.28 247.58,98.37 247.94,98.73 247.94,103.98 249.99,106.03 249.99,114.23 250.54,114.79 251.38,114.79 252.18,115.59 252.18,122.67 258.42,128.92 286.98,128.92 289.65,126.24 289.95,126.24 290.24,125.94 290.24,125.51 v2(290.08,125.34)
  BOTTOM w0.112: JDEG1.3 v2(290.08,125.34) 290.06,125.36 RPE7.2
KB_DET#: length 165.8
  TOP w0.112: v2(149.81,119.72) 149.81,118.93 150.7,118.04 150.7,113.44 149.81,112.55 149.81,110.09 150.7,109.2 150.7,108.64 149.87,107.81 149.87,106.14 150.61,105.41 v1(150.61,104.56) v2(151.39,103.77)
  IN2 w0.124: v2(140.94,81.32) 140.94,81.29 139.11,79.46 139.11,75.78 143.1,71.79 143.1,70.57 147.69,65.99 148.52,65.99 149.48,65.03 158.08,65.03 160.5,62.61 160.5,61.07 160.82,60.75 165.27,60.75 165.79,61.27 169.35,61.27 171.06,59.55 180.11,59.55 180.72,58.94 182.79,58.94 183.12,59.26 195.58,59.26 196.24,58.6 200.2,58.6 204.36,54.44 205.97,54.44 v2(206.48,54.95)
  IN3 w0.135: v2(140.94,81.32) 141.46,81.83 141.46,83.15 141.89,83.59 143.75,83.59 145.1,84.93 145.1,88 149.11,92.02 149.11,92.45 149.5,92.83 149.5,94.76 v2(149.12,95.14) ; v2(134.65,120.47) 134.65,120.74 135.17,121.26 148.27,121.26 v2(149.81,119.72)
  BOTTOM w0.076: RC288.1 134.65,120.78 v2(134.65,120.47) ; 131.62,115.86 131.41,115.64 131.41,115.55 130.12,114.26 130.02,114.26 129.15,113.39 129.15,112.54 129.09,112.47 129.09,112.22 129.18,112.1 129.18,111.9 128.97,111.69 UC1.D8
  BOTTOM w0.112: JKBTP1.20 204.55,57.63 205.45,56.73 205.45,55.65 206.15,54.95 v2(206.48,54.95) ; v2(151.39,103.77) 150.93,103.77 149.95,102.79 149.95,102.33 149.42,101.8 149.42,96.66 149.16,96.4 149.16,95.18 v2(149.12,95.14) ; v2(134.65,120.47) 134.65,120.1 134.96,119.78 134.96,119.2 131.62,115.86
LAN_ACTLED_YEL#: length 35.5
  TOP w0.112: RL14.1 282.41,127.65 280.12,129.93 263.8,129.93 262.81,130.92 262.81,132.64 261.64,133.81 v1(259.41,133.81) v2(257.79,133.81)
  BOTTOM w0.112: QL1.6 v2(257.79,133.81)
LAN_ACTLED_YEL_R#: length 107.4
  TOP w0.102: v2(282.41,119.56) v3(282.41,118.84)
  TOP w0.112: RL14.2 v2(282.41,119.56)
  IN3 w0.135: v2(282.41,119.56) 282.41,127.71 281.55,128.57 259.12,128.57 252.68,122.13 252.68,116.32 257.63,111.36 264.73,111.36 272.16,103.93 272.16,100.07 273.78,98.45 275.51,98.45 276.72,97.25 276.72,85.68 277.49,84.9 280.63,84.9 281.47,85.74 281.47,90.55 JLOM1.10
LAN_DISABLE#_R: length 5.7
  TOP w0.112: UL1.3 244.88,122.26 244.31,121.69 244.31,121.37 RL9.1 242.92,119.99 RL5.1 RL7.2 242.93,119.07 v1(242.93,118.07)
LAN_MDIN0: length 4.2
  TOP w0.089: RL72.1 251.71,122.72 250.95,122.72 250.71,122.96 250.71,123.72 v4(250.54,123.89) 250.37,124.06 249.98,124.06 249.91,124.13 UL1.14
LAN_MDIN0_L: length 23.9
  TOP w0.089: RL72.2 254.06,122.72 254.31,122.72 254.55,122.96 254.55,124.3 256.5,126.25 v4(265,126.25) 270.18,126.25 270.94,127.01 271.22,127.01 v2(271.38,127.17)
  BOTTOM w0.089: v2(271.38,127.17) 271.38,127.14 271.59,126.93 271.95,126.93 272.04,127.02 272.04,127.61 271.95,127.7 271.51,127.7 271.42,127.79 TL1.11
LAN_MDIN1: length 3.4
  TOP w0.089: UL1.18 249.91,125.73 249.98,125.66 250.68,125.66 v4(250.95,125.39) 251.2,125.14 251.71,125.14 RL74.1
LAN_MDIN1_L: length 14.4
  TOP w0.089: v2(263.81,127.3) 263.65,127.14 256.18,127.14 254.18,125.14 253.93,125.14 253.58,125.49 RL74.2
  BOTTOM w0.089: v2(263.81,127.3) 263.98,127.14 264.35,127.14 264.44,127.22 264.44,127.61 264.35,127.7 263.89,127.7 263.8,127.79 TL1.5
LAN_MDIN2: length 3.2
  TOP w0.089: RL76.1 251.45,127.55 251.04,127.55 250.61,127.12 250.35,126.86 249.98,126.86 249.91,126.93 UL1.21
LAN_MDIN2_L: length 17.1
  TOP w0.089: v2(266.21,127.31) 266.09,127.19 265.65,127.19 264.69,128.15 255.02,128.15 254.41,127.55 253.68,127.55 253.33,127.9 RL76.2
  BOTTOM w0.089: v2(266.21,127.31) 266.38,127.14 266.94,127.14 267.03,127.23 267.03,127.61 266.94,127.7 266.43,127.7 266.34,127.79 TL1.7
LAN_MDIN3: length 4.4
  TOP w0.089: RL78.1 251.32,129.96 250.82,129.96 v4(250.64,129.79) 250.4,129.55 250.4,128.15 250.32,128.06 249.98,128.06 249.91,128.13 UL1.24
LAN_MDIN3_L: length 9.1
  TOP w0.089: v2(259.07,130.46) 259.26,130.26 259.26,129.78 259.06,129.59 253.91,129.59 253.2,130.3 RL78.2
  BOTTOM w0.089: v2(259.07,130.46) 259.23,130.29 259.23,130.06 258.72,129.55 TL1.1
LAN_MDIP0: length 4.2
  TOP w0.089: RL71.1 251.71,122.47 v4(251.08,122.47) 250.84,122.47 250.46,122.86 250.46,123.62 250.27,123.81 249.98,123.81 249.91,123.73 UL1.13
LAN_MDIP0_L: length 23.9
  TOP w0.089: v2(271.38,126.59) 271.22,126.76 271.04,126.76 270.28,126 v4(267.3,126) 256.61,126 254.8,124.19 254.8,122.86 254.41,122.47 254.06,122.47 RL71.2
  BOTTOM w0.089: 272.69,128.94 272.69,128.12 272.29,127.72 272.29,126.92 272.06,126.68 271.48,126.68 v2(271.38,126.59)
LAN_MDIP1: length 3.4
  TOP w0.089: UL1.17 249.91,125.33 249.98,125.41 250.57,125.41 251.1,124.88 251.71,124.88 RL73.1
LAN_MDIP1_L: length 14.4
  TOP w0.089: v2(263.81,126.72) 263.65,126.88 v4(261.57,126.88) 256.29,126.88 254.29,124.88 253.93,124.88 253.58,124.53 RL73.2
  BOTTOM w0.089: v2(263.81,126.72) 263.98,126.88 264.46,126.88 264.69,127.12 264.69,127.57 265.07,127.95 TL1.6
LAN_MDIP2: length 3.2
  TOP w0.089: RL75.1 251.45,127.3 251.14,127.3 v4(250.79,126.94) 250.45,126.61 249.98,126.61 249.91,126.53 UL1.20
LAN_MDIP2_L: length 17.1
  TOP w0.089: v2(266.21,126.72) 265.99,126.94 265.55,126.94 264.59,127.9 v4(255.62,127.9) 255.12,127.9 254.52,127.3 253.68,127.3 253.33,126.95 RL75.2
  BOTTOM w0.089: v2(266.21,126.72) 266.37,126.89 267.05,126.89 267.28,127.12 267.28,127.77 267.61,128.1 TL1.8
LAN_MDIP3: length 4.4
  TOP w0.089: UL1.23 249.91,127.73 249.98,127.81 250.42,127.81 250.66,128.04 v4(250.66,128.41) 250.66,129.45 250.77,129.56 250.92,129.71 251.32,129.71 RL77.1
LAN_MDIP3_L: length 9.1
  TOP w0.089: v2(259.65,130.46) 259.51,130.32 259.51,129.68 259.17,129.34 v4(255.07,129.34) 253.3,129.34 RL77.2
  BOTTOM w0.089: v2(259.65,130.46) 259.48,130.29 259.48,130.06 259.99,129.55 TL1.2
LAN_TEST_EN: length 3.8
  TOP w0.112: v2(246.27,129.86) 246.48,129.66 UL1.30
  BOTTOM w0.112: RL12.1 246.04,129.63 v2(246.27,129.86) 246.7,130.29 v1(248.14,130.29)
LAN_WAKE#: length 253.6
  TOP w0.107: UE1.L3 v2(255.08,85.06)
  TOP w0.112: v2(139.48,105.28) 141.89,105.28 142.62,106.01 144.98,106.01 145.64,105.34 v2(145.64,103.72) ; v2(164.42,116.49) 164.42,116.91 v1(163.25,118.08) 160.2,121.13 158.03,121.13 154.48,117.58 154.48,113.73 153.83,113.08 153.83,107.86 153.53,107.55 153.53,107.07 v2(153.94,106.67) ; v2(244.01,121.98) 244.05,122.03 244.26,122.03 244.48,122.25 UL1.2
  IN1 w0.119: v2(244.01,121.98) 243.8,121.77 243.8,111.44 244.14,111.09 244.14,105.07 240.35,101.27 240.35,97.23 241.65,95.93 241.65,92.81 243.39,91.07 v2(243.39,88.35)
  IN2 w0.124: v2(139.48,105.28) 139.48,104.58 138.58,103.68 138.33,103.68 137.46,102.81 137.46,99.03 136.3,97.86 136.3,96.53 135.73,95.96 131.8,95.96 130.07,97.69 124.59,97.69 124.31,97.41 124.31,96.89 124.53,96.66 v2(124.74,96.66) ; v2(164.42,116.49) 164.42,111.34 169.42,106.34 169.42,90.96 171.28,89.1 171.28,86.56 173.63,84.21 173.63,82.23 182.63,73.23 185.49,73.23 187.57,71.14 213.53,71.14 214.5,72.11 216.45,72.11 218.01,73.67 223.26,73.67 224.85,75.25 224.85,78.66 225.22,79.03 230.96,79.03 231.7,78.29 234.64,78.29 237.01,80.66 237.01,81.29 236.13,82.17 236.13,85.34 237.5,86.7 237.5,87.81 239,89.32 240.85,89.32 242.05,88.11 242.51,88.11 242.75,88.35 v2(243.39,88.35) 244.22,89.19 250.32,89.19 250.69,89.56 250.69,90.05 250.91,90.26 251.3,90.26 253.08,88.48 253.08,85.66 253.29,85.46 254.63,85.46 255.03,85.06 v2(255.08,85.06)
  BOTTOM w0.102: UC1.AM15 124.66,96.66 v2(124.74,96.66)
  BOTTOM w0.112: v2(153.94,106.67) 152.25,106.67 149.99,104.4 147.39,104.4 146.89,103.9 RC323.1 RL70.1 v2(145.64,103.72)
LCD_CBL_DET#: length 106.4
  TOP w0.112: RC287.1 134.24,102.96 v2(133.7,102.42)
  IN2 w0.124: v2(74.98,124.6) 75.43,124.14 81.59,124.14 82.86,125.41 85.88,125.41 86.08,125.2 89.49,125.2 90.46,126.17 93.27,126.17 93.44,126.35 95.3,126.35 95.67,126.71 98.75,126.71 99.08,126.38 103.96,126.38 104.37,126.78 109.09,126.78 109.51,127.21 118.98,127.21 119.37,127.6 121.84,127.6 122.6,126.83 125.54,126.83 125.91,127.2 128.13,127.2 128.77,126.57 133.5,126.57 134.99,125.08 134.99,123.15 134.62,122.78 134.62,121.05 134.26,120.69 134.26,120.3 134.49,120.07 134.86,120.07 135.46,119.47 135.46,111.35 135.19,111.08 135.19,110.72 135.63,110.27 135.63,108.68 137.93,106.39 137.93,104.24 136.57,102.88 134.16,102.88 v2(133.7,102.42)
  BOTTOM w0.102: v2(133.7,102.42) 133.3,102.02 132.83,102.02 132.64,102.2 130.98,102.2 130.79,102.01 UC1.AC3
  BOTTOM w0.112: JEDP1.40 70.75,132.14 70.84,132.05 71.02,132.05 72.37,130.7 72.37,128.57 74.57,126.36 74.57,125 v2(74.98,124.6)
LCD_TST: length 250.8
  TOP w0.107: UE1.D1 249.08,83.49 248.72,83.12 v1(248.72,82.28) 248.72,82.19 248.1,81.57 v2(248.1,81.57) 248.1,81.57 248.1,81.03 RE20.1
  IN2 w0.124: v2(65.37,133.81) 65.89,133.28 70.38,133.28 73.1,130.56 74.77,130.56 76.13,129.2 79.05,129.2 83.59,133.74 88.1,133.74 89.9,135.55 144.72,135.55 148.89,131.37 153.22,131.37 154.19,132.33 156.5,132.33 157.31,131.52 158.65,131.52 159.85,130.31 159.85,124.06 163.57,120.35 163.57,110.96 168.5,106.03 168.5,90.89 170.58,88.82 170.58,86.23 172.95,83.85 172.95,81.59 182.44,72.1 185.66,72.1 187.34,70.42 206.86,70.42 207.9,69.38 221.09,69.38 221.79,70.08 225.5,70.08 225.8,70.39 226.68,70.39 228.11,71.82 228.11,72.69 229.74,74.32 231.43,74.32 231.53,74.22 232.69,74.22 235.1,76.63 235.1,77.03 236.61,78.54 244.45,78.54 244.88,78.11 246.6,78.11 247.29,77.42 v2(247.29,77)
  IN3 w0.135: v2(248.1,81.57) 248.49,81.18 248.49,78.2 v2(247.29,77)
  BOTTOM w0.107: JEDP1.29 65.25,133.69 v2(65.37,133.81)
LCD_VCC_TEST_EN: length 243
  TOP w0.107: UE1.E1 249.02,82.99 249.02,82.46 249.3,82.18 v2(249.5,82.18)
  TOP w0.112: DV3.2 v2(70.46,123.44)
  IN1 w0.119: v2(248.44,74.23) 248.44,75.11 250.01,76.68 250.01,81.88 249.71,82.18 v2(249.5,82.18)
  IN2 w0.124: v2(248.44,74.23) 247.89,74.77 241.57,74.77 238.24,71.45 236.82,71.45 235.78,70.4 234.36,70.4 232.95,68.99 231.66,68.99 231.25,68.58 226.76,68.58 226.11,67.93 222.99,67.93 222.33,67.28 207.21,67.28 205.92,68.57 186.64,68.57 184.91,70.29 181.25,70.29 171.13,80.41 171.13,83.11 168.77,85.48 168.77,88.04 166.4,90.41 166.4,105.4 161.76,110.03 161.76,116.97 159.59,119.15 159.59,121.11 154.44,126.25 148.3,126.25 147.28,127.26 146.37,127.26 142.25,131.38 141.12,131.38 140.09,132.41 136.04,132.41 134.78,131.14 131.22,131.14 130.26,130.19 127.08,130.19 126.5,129.6 124.86,129.6 124.15,130.31 122.17,130.31 121.99,130.14 118.08,130.14 117.78,129.83 108.64,129.83 108.13,129.33 104.74,129.33 104.24,129.83 83.52,129.83 80.12,126.43 73.87,126.43 v2(73.68,126.25)
  BOTTOM w0.112: v2(73.68,126.25) 72.82,125.38 72.82,124.11 72.15,123.44 v1(71.53,123.44) v2(70.46,123.44)
LED_10_GRN#: length 30.8
  TOP w0.112: RL19.1 v1(281.46,124.24) 281.46,128.03 279.81,129.68 263.7,129.68 262.56,130.82 262.56,132.32 261.77,133.1 v2(261.26,133.1)
  BOTTOM w0.112: QL2.6 v2(261.26,133.1)
LED_10_GRN_R#: length 7.4
  TOP w0.112: RL19.2 280.52,119.2 v3(280.52,118.91) 280.52,117.9 JLOM1.11
LED_100_ORG#: length 34.8
  TOP w0.112: RL20.1 v1(280.5,122.39) 280.5,128.47 279.55,129.42 263.68,129.42 263.12,128.87 260.45,128.87 260.12,129.2 260.12,130.82 259.8,131.14 258.85,131.14 258.15,130.44 256.84,130.44 v2(256.79,130.49)
  BOTTOM w0.112: v2(256.79,130.49) 256.49,130.8 QL1.3
LED_100_ORG_R#: length 11.5
  TOP w0.112: RL20.2 280.25,120.39 279.34,120.39 v3(279.04,120.1) 279.04,117.08 JLOM1.13
LG1_ISL88738: length 21.5
  IN3 w1.016: 59.23,60.79 59.23,62.03 56.79,64.46 47.33,64.46 42.12,69.67
  vias: v2(41.62,71) v2(42.32,70.69) v2(58.37,59.52) v2(58.75,59.95)
LG2_ISL88738: length 13
  TOP w0.508: PQ904.6 v2(53.47,65.42)
  IN1 w0.508: v2(53.47,65.42) 53.82,65.06 57.28,65.06 60.1,62.24 60.1,58.84 v2(59.87,58.61)
  BOTTOM w0.112: v2(59.87,58.61) v1(59.87,59.19)
LID_CL#: length 116.8
  TOP w0.112: RE26.1 v2(261.97,96.37) 262.39,95.95 v3(262.76,95.95) ; v2(267.84,85.51) 267.87,85.48 UZ10.2
  IN2 w0.124: v2(267.84,85.51) 268.78,84.57 268.78,82.19 269.2,81.78 270.53,81.78 272.83,79.48 272.83,75.69 275.79,72.74 279.29,72.74 280.03,72 281.32,72 283,70.32 283,63.15 282.03,62.17 282.03,56.59 279.75,54.31 279.75,31.53 287.88,23.4 287.88,13.55 286.73,12.39 286.73,11.23 287.93,10.02 288.9,10.02 289.33,9.59 289.33,6.7 v2(290.73,5.31)
  BOTTOM w0.112: JLED1.5 v2(290.73,5.31) ; v2(261.97,96.37) 265.19,96.37 267.83,93.72 267.83,91.24 267.12,90.52 267.12,86.24 v2(267.84,85.51)
LID_CL#_NB: length 8.1
  TOP w0.107: RE26.2 RE25.2 259.31,96.09 CE8.1 258.63,95.44 v1(258.63,94.88) 258.63,93.38 257.11,91.86 UE1.N11
LID_CL#_PCH: length 10.4
  BOTTOM w0.076: UC1.AW7 128.66,92.45 128.98,92.14 128.98,90.82 130.34,89.46 130.47,89.46
  BOTTOM w0.112: T268.1 135.89,87.49 134.9,88.48 132.23,88.48 131.25,89.46 130.47,89.46
LM393_P: length 16
  IN1 w0.254: v2(38.63,58.3) 39.01,58.68 44.54,58.68 v2(45.24,57.99)
  BOTTOM w0.203: PD1801.1 37.03,57.78 PC1201.2 36.47,56.91 36.35,56.78 36.35,56.27 36.58,56.04 PU1201.8
  BOTTOM w0.254: PU903.5 44.05,55.4 43.86,55.59 43.86,56.06 PC949.2 44.87,57.06 v1(44.87,57.5) 44.87,57.62 v2(45.24,57.99) 45.24,58.48 PR950.2 ; PD1801.1 v2(38.63,58.3)
LOM_ACTLED_YEL#: length 14.6
  TOP w0.112: v2(249.58,129.8) 249.13,130.25 v1(248.66,130.25) 248.56,130.25 248.08,129.76 UL1.26
  IN1 w0.119: v2(249.58,129.8) 249.58,131.71 250.6,132.73 257.52,132.73 257.79,132.46 v2(257.79,131.9)
  BOTTOM w0.112: QL1.1 v2(257.79,131.9)
LOM_CABLE_DETECT#: length 57.6
  TOP w0.107: v2(248.1,82.2) 248.1,82.21 248.1,82.91 248.7,83.51 248.7,84.28 UE1.D2
  IN1 w0.119: v2(248.1,82.2) 248.33,82.2 249.88,83.75 249.88,88.07 251.69,89.88 251.69,92.64 251.81,92.77 251.81,93.76 251.36,94.22 251.36,95.49 251.67,95.81 251.67,96.52 252.25,97.09 252.25,98.37 252.12,98.5 252.12,108.27 251.41,108.98 251.41,110.15 251.89,110.63 251.89,111.54 251.53,111.9 v2(251.53,113.49)
  IN2 w0.124: v2(251.53,113.49) 252.23,114.18 252.23,124.38 254.04,126.19 v2(254.04,128.43)
  BOTTOM w0.112: UL2.4 253.45,131.44 253.66,131.24 253.66,130.31 v1(253.83,130.14) 254.04,129.93 v2(254.04,128.43) 254.04,127.77 RE505.1
LOM_SPD10LED_GRN#: length 24.2
  TOP w0.112: RL30.2 256.55,133.12 256.84,132.83 v2(256.84,132.28) 256.91,132.34 v1(257.43,132.34) 260.14,132.34 v2(260.64,131.84) ; v2(248.94,129.8) 248.75,129.8 248.48,129.53 UL1.25
  IN1 w0.119: v2(248.94,129.8) 248.94,131.52 250.53,133.11 259.99,133.11 260.64,132.46 v2(260.64,131.84)
  BOTTOM w0.112: QL2.1 v2(260.64,131.84) ; v2(256.84,132.28) 256.65,132.09 UL2.2
LOM_SPD100LED_ORG#: length 14
  TOP w0.112: UL1.27 247.68,129.88 249.31,131.52 252.69,131.52 v1(253.41,132.24) 254.29,133.12 RL29.2 255.23,133.55 255.55,133.87 v2(256.31,133.87)
  BOTTOM w0.112: UL2.1 256.12,132.74 QL1.4 256.49,133.69 v2(256.31,133.87)
LPS_PROTECT#: length 1
  TOP w0.112: PR1248.2 32.41,58.48 PT1.1
LPSS_UART2_RXD: length 80
  TOP w0.112: v2(130.28,133.23) 130.08,133.43 130.08,133.59 130.18,133.69 131.92,133.69 134.79,130.82 134.79,128.74 136.02,127.51 138.57,127.51 139.58,126.5 141.76,126.5 142.3,125.96 145.05,125.96 146.4,124.62 149.97,124.62 152.73,121.86 152.73,114.52 152.26,114.04 152.26,109.47 152.49,109.24 152.49,108.39 152.23,108.12 152.23,106.01 153.99,104.25 153.99,98.96 152.77,97.74 147.92,97.74 145.81,99.84 145.58,99.84 v2(145.38,100.05)
  BOTTOM w0.076: 135.53,99.52 135.51,99.54 135.49,99.54 134.33,100.7 132.71,100.7 132.53,100.52 132.42,100.52 UC1.AD1
  BOTTOM w0.107: RC330.1 145.83,100.05 v2(145.38,100.05)
  BOTTOM w0.112: v2(145.38,100.05) 144.64,100.79 143.78,100.79 RC402.1 142.93,99.94 140.71,99.94 140.25,100.4 138.84,100.4 137.88,99.45 135.6,99.45 135.53,99.52 ; v2(130.28,133.23) 130.12,133.08 130.12,132.85 130.41,132.57 JUART1.3
LPSS_UART2_TXD: length 81.8
  TOP w0.112: v2(145.38,99.45) 145.53,99.6 145.71,99.6 147.82,97.5 152.87,97.5 154.23,98.86 154.23,104.34 152.46,106.11 152.46,108.02 152.73,108.29 152.73,109.34 152.5,109.57 152.5,113.94 152.97,114.42 152.97,121.96 150.07,124.85 146.5,124.85 145.15,126.2 142.39,126.2 141.86,126.74 139.68,126.74 138.67,127.75 136.11,127.75 135.03,128.84 135.03,130.92 132.02,133.93 130.08,133.93 129.84,133.69 129.84,133.38 v2(129.69,133.23)
  BOTTOM w0.076: UC1.AD2 132.05,100.24 132.54,100.24 132.79,100.49 134.24,100.49 135.34,99.39 135.34,99.37 135.36,99.35
  BOTTOM w0.107: v2(145.38,99.45) 145.87,99.45 RC331.1
  BOTTOM w0.112: 135.36,99.35 135.5,99.21 137.98,99.21 138.93,100.17 140.15,100.17 140.61,99.71 142.95,99.71 RC403.1 143.78,98.88 144.81,98.88 145.18,99.24 145.18,99.25 v2(145.38,99.45) ; JUART1.2 129.61,132.57 129.87,132.83 129.87,133.06 v2(129.69,133.23)
LX1_ISL88738: length 17.3
  IN1 w1.016: 58.19,61.61 56.35,63.45 52.48,63.45 49.36,66.56 49.36,70.69 48.79,71.26 47.27,71.26
  vias: v2(43.08,71.03) v2(43.08,70.46) v2(43.71,71.03) v2(43.71,70.46) v2(44.35,71.03) v2(44.35,70.46) v2(44.98,71.03) v2(44.98,70.46) v2(45.62,70.46) v2(46.25,70.46) v2(46.48,68.97) v2(46.48,68.34) v2(46.48,67.7) v2(47.08,68.97) v2(47.08,68.34) v2(47.08,67.7) v2(57.71,59.9) v2(58.09,60.36) v3(42.89,72.27)
LX2_ISL88738: length 10.5
  IN1 w0.508: v2(59.87,57.97) 60.5,57.97 61.01,58.48 61.01,62.47 57.66,65.82 v2(57.28,65.82)
  vias: v1(57.38,69.38) v2(55.68,69.68) v2(55.85,68.77) v2(55.85,68.03) v2(55.85,67.3) v2(55.85,66.56) v2(55.85,65.82) v2(56.29,69.68) v2(56.56,68.77) v2(56.56,68.03) v2(56.56,67.3) v2(56.56,66.56) v2(56.56,65.82) v2(56.89,69.68) v2(57.28,68.77) v2(57.28,68.03) v2(57.28,67.3) v2(57.28,66.56)
