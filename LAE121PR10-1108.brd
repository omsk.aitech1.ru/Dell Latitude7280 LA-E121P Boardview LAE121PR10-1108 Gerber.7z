# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_WAKE#_R: length 32
  TOP w0.107: v2(258.09,95.45) 258.09,95.06 256.49,93.46 UE1.N13
  TOP w0.112: v2(263.08,79.83) v1(262.33,79.08) RE275.1 ; v2(258.09,95.45) 258.41,95.77 RE35.1
  BOTTOM w0.112: v2(258.09,95.45) 258.63,95.99 259.86,95.99 260.4,96.53 261.19,96.53 261.77,95.95 264.78,95.95 266.77,93.95 266.77,83.53 v2(263.08,79.83)
PD1_GPIO0: length 3.6
  TOP w0.076: 34.69,84.51 33.77,83.59 33.77,83.22 UT5.B2
  TOP w0.112: 34.69,84.51 34.85,84.67 34.85,84.97 35.28,85.41 RT69.1
PD1_GPIO2: length 4.6
  TOP w0.076: UT5.D10 32.27,78.72 32.27,77.31
  TOP w0.112: v2(32.38,76.97) 32.38,76.97 32.27,77.08 32.27,77.31
  BOTTOM w0.112: RT71.1 33.03,78.48 32.75,78.2 v1(32.75,77.73) 32.75,77.34 v2(32.38,76.97)
PD1_GPIO5: length 3.7
  TOP w0.076: 31.77,77.31 31.77,78.72 UT5.E10
  TOP w0.112: 31.77,77.31 31.77,77.2 v2(31.55,76.97)
  BOTTOM w0.112: RT74.1 31.79,77.21 v2(31.55,76.97) 31.44,76.87 v1(30.99,76.87)
PD1_GPIO6: length 5.5
  TOP w0.076: 30.16,77.31 30.77,77.92 30.77,78.72 UT5.G10
  TOP w0.112: RT75.1 29.5,75.02 29.42,75.09 29.42,76.66 29.56,76.8 29.64,76.8 30.16,77.31
PD1_GPIO7: length 3.5
  TOP w0.076: v2(32.99,80.73) 32.78,80.73 UT5.D7
  BOTTOM w0.112: v1(30.45,79.84) 30.61,80 31.76,80 RT339.1 32.5,80.73 v2(32.99,80.73)
PD1_GPIO8: length 4.1
  TOP w0.076: v2(30.05,81.32) 30.18,81.32 UT5.H6
  BOTTOM w0.112: v1(27.96,83.48) 28.42,83.02 RT76.1 28.75,82.26 28.75,81.89 RT377.1 30.02,81.34 v2(30.05,81.32)
PD#: length 9.5
  TOP w0.112: UA1.47 260.73,62.14 261.01,62.42 261.01,63.16 261.36,63.51 261.36,64.11 v1(261.72,64.46) 262.34,65.09 262.34,66.05 CA31.1 262.66,66.8 262.99,67.13 RA18.1 262.99,68.07 DA8.2 262.08,68.27 RA48.2 RA50.2
PECI_EC: length 245.4
  TOP w0.112: RE60.2 253.97,96.67 254.28,96.98 v2(254.28,97.37) ; v2(153.73,124.75) v1(153.73,124.04)
  IN1 w0.119: v2(153.73,124.75) 153.28,124.29 146.22,124.29 146.13,124.38 139.36,124.38 139.2,124.21 133.49,124.21 132.19,122.92 v2(131.63,122.92)
  IN2 w0.124: v2(131.63,122.92) 131.42,123.12 128.83,123.12 128.51,123.44 120.72,123.44 119.86,124.3 119.41,124.3 119.25,124.13 118.2,124.13 116.94,122.87 110.05,122.87 109.75,122.57 102.97,122.57 v2(102.51,123.03) ; v2(153.73,124.75) 154.17,124.75 158.43,120.49 158.43,118.67 159.96,117.14 159.96,109.6 160.48,109.08 161,109.08 163.54,106.54 163.54,105.68 164.31,104.9 164.31,90.86 167.61,87.57 167.61,85 169.95,82.66 169.95,79.61 171.44,78.12 171.44,73.79 171.77,73.45 175.82,73.45 180.14,69.14 184.43,69.14 186.19,67.37 205.36,67.37 206.68,66.05 226,66.05 227.37,67.42 231.4,67.42 231.54,67.28 232.88,67.28 234.84,69.25 236.26,69.25 236.72,69.7 239.94,69.7 242.61,72.38 243.13,72.38 243.71,72.96 248.85,72.96 249.06,73.16 251.98,73.16 253.16,74.34 258.37,74.34 v2(258.6,74.11)
  BOTTOM w0.076: UC1.A54 101.74,113.42 101.74,114.64 101.22,115.16 101.22,115.87 101.37,116.03 101.37,117.11 101.18,117.3 101.18,118.82 101.53,119.17
  BOTTOM w0.102: v2(102.51,123.03) 101.58,122.11 101.58,119.22 101.53,119.17
  BOTTOM w0.112: v2(258.6,74.11) 258.8,74.32 258.8,75.87 258.62,76.05 258.62,77.1 258.52,77.2 258.52,78.18 259.72,79.38 259.72,84.77 259.61,84.88 259.61,85.96 258.39,87.17 257.91,87.17 257.01,88.08 257.01,90.54 255.99,91.55 255.99,93.33 254.28,95.04 v2(254.28,97.37)
PECI_EC_R: length 2.5
  TOP w0.107: UE1.K13 253.52,93.83 253.52,94.7 v1(253.64,94.83) RE60.1
PGOOD_3V: length 58.8
  TOP w0.254: v2(152.51,77.54) 147.57,77.54 147.38,77.35 v2(146.84,77.35)
  IN3 w0.203: v2(178.56,58.41) 177.82,58.41 176.78,59.45 173.99,59.45 173.81,59.63 168.21,59.63 167.34,58.76 166.22,58.76 165.94,58.48 159.76,58.48 158.85,59.4 158.85,66.61 157.78,67.68 150.87,67.68 146.71,71.84 146.71,77.23 v2(146.84,77.35)
  BOTTOM w0.112: v2(152.51,77.54) v1(151.79,77.54)
  BOTTOM w0.254: v2(152.51,77.54) 152.51,77.04 152.17,76.69 152.17,76.22 152.49,75.9 PU100.9 ; v2(178.56,58.41) 178.56,58.08 PR119.1 179.04,57.59 PR107.2
PGOOD_5V: length 2.8
  BOTTOM w0.254: PR120.1 180.83,56.69 PR113.2 182.36,56.69 182.96,56.09 PU102.9
PLTRST_LAN#: length 199.4
  TOP w0.112: v2(243.56,129.35) 243.69,129.47 243.93,129.47 244.08,129.33 UL1.36 ; v2(160,119.45) 159.2,119.45 157.19,117.44 157.19,114.78 156.97,114.56 v1(156.97,113.61) 156.97,111.31 156.44,110.79 v2(156.44,107.73)
  IN1 w0.119: v2(229.69,63.87) 229.33,63.5 221.12,63.5 220.65,63.97 195.83,63.97 arc(183.77,66.37) 173.55,73.2 173.18,73.57 171.35,73.57 170.95,73.96 169.73,73.96 169.34,74.36 169.34,78.13 169.34,78.13 arc(167.39,81.08) 165.76,84.21 arc(163.16,91.87) 162.28,99.91 162.28,100.47 159.11,103.64 159.11,104 156.44,106.67 v2(156.44,107.73)
  IN3 w0.135: v2(229.69,63.87) 230.04,64.21 232.85,64.21 233.79,65.15 235.49,65.15 237.34,67 238.79,67 239.52,67.73 239.52,68.41 241.12,70.01 241.12,77.48 240.44,78.17 240.44,80.15 239.86,80.72 239.86,81.8 239.38,82.28 237.63,82.28 237.02,82.89 236.23,82.89 235.89,83.23 235.89,89.77 240.3,94.18 240.3,99.04 241.15,99.89 241.15,106.95 240.76,107.34 240.76,120.54 239.85,121.45 239.85,122.34 240.41,122.9 240.41,127.57 241.31,128.47 242.68,128.47 v2(243.56,129.35)
  BOTTOM w0.112: RC62.2 v2(160,119.45)
PLTRST_TPM#: length 14.8
  TOP w0.112: v2(161.05,106.62) 159.94,107.72 159.94,114.16 v1(159.62,114.48) 157.71,116.39 v2(157.71,116.89)
  BOTTOM w0.112: v2(157.71,116.89) 158,116.89 158.72,117.61 RC325.2 RC60.2 ; v2(161.05,106.62) 160.83,106.84 UZ12.17
PM_LANPHY_ENABLE: length 240.6
  TOP w0.112: RL7.1 242.01,118.84 242.59,118.26 242.59,117.74 v1(240.74,115.89) 239.93,115.08 v2(239.93,114.79)
  IN2 w0.124: v2(239.93,114.79) 239.93,113.15 244.69,108.39 244.69,107.9 246.77,105.81 255.72,105.81 256.32,105.22 259.05,105.22 261.9,102.37 262.15,102.37 262.81,101.71 262.81,99.81 262.91,99.71 262.91,92.9 263.79,92.02 263.79,88.6 264.66,87.74 264.66,86.64 265,86.3 265,83.63 265.34,83.29 265.72,83.29 266.59,82.42 266.59,79.18 265.86,78.45 265.86,75.02 261.99,71.15 261.99,69.79 260.58,68.38 260.49,68.38 258.77,66.66 255.83,66.66 255.52,66.36 252.45,66.36 251.43,65.34 249.19,65.34 244.37,60.51 244.37,59.62 242.63,57.87 236.91,57.87 234.31,55.28 233.49,55.28 233.18,54.98 230.43,54.98 229.66,55.75 226.47,55.75 225.82,56.4 225.82,56.83 225.21,57.44 218.76,57.44 218.23,57.97 216.85,57.97 215.02,56.14 207.42,56.14 206.91,56.65 203.75,56.65 200.01,60.39 181.89,60.39 181.59,60.69 173.59,60.69 170.14,64.14 161.88,64.14 158.36,67.66 149.55,67.66 149.2,68.01 148.72,68.01 145.29,71.44 145.29,72.19 143.2,74.27 143.2,75.68 141.63,77.25 v2(141.63,77.43)
  BOTTOM w0.076: 123.87,87.16 123.87,87.26 122.44,88.7 122.44,90.27 122.24,90.46 122.24,90.83 122.29,90.94 122.29,91.06 122.23,91.28 122.23,91.42 122.28,91.58 122.28,91.66 122.5,92.36 122.5,92.36 122.67,92.54 UC1.AW17
  BOTTOM w0.112: v2(141.63,77.43) 140.82,77.43 140.64,77.25 130.08,77.25 126.64,80.69 126.64,82.94 123.87,85.71 123.87,87.16
PME#: length 2.8
  TOP w0.112: v2(125.66,93.44) 125.27,93.84 125.27,95.07 125.08,95.26 T115.1
  BOTTOM w0.076: v2(125.66,93.44) 125.66,93.5 125.97,93.8 UC1.AU11
POA_WAKE#: length 45
  TOP w0.107: UE1.E4 v2(249.48,85.86)
  TOP w0.112: v2(246.25,76.49) 246.21,76.45 RE324.1 ; v2(232.31,60.06) 232.62,59.74 v1(232.62,59.13)
  IN3 w0.135: v2(249.48,85.86) 249.08,85.46 249.08,84 247.69,82.6 247.69,81.24 248.06,80.86 248.06,78.84 246.67,77.44 246.67,76.91 v2(246.25,76.49) 246.25,76.03 247.19,75.09 247.19,70.11 246.77,69.7 246.77,67.11 243.21,63.54 243.21,60.66 241.21,58.66 234.13,58.66 233.67,59.12 232.81,59.12 232.31,59.62 v2(232.31,60.06)
  BOTTOM w0.112: v2(232.31,60.06) 231.95,59.7 JUSH1.4
PORT80_DET#: length 34.1
  TOP w0.107: UE1.K4 v2(254.28,85.86)
  TOP w0.112: RE512.1 239.83,87.62 240.64,87.62 RE513.1 241.47,87.8 v1(242.09,87.8) 242.21,87.93 v2(242.21,88.5) ; v2(239.38,98.44) 238.86,98.96 RZ131.1
  IN1 w0.119: v2(239.38,98.44) 239.74,98.44 240.1,98.07 240.1,97.16 241.43,95.84 241.43,92.72 242.21,91.93 v2(242.21,88.5)
  IN2 w0.124: v2(242.21,88.5) 243.15,89.44 249.68,89.44 249.89,89.65 249.89,90.06 250.09,90.26 250.48,90.26 250.66,90.43 250.66,90.48 250.69,90.51 250.69,90.82 250.79,90.91 250.79,90.94 250.91,91.06 251.25,91.06 251.25,91.07 251.29,91.07 251.61,90.75 251.61,90.28 253.01,88.89 253.49,88.89 253.88,88.49 UE1.K4 v2(254.28,85.86)
POWER_SW#_MB: length 131
  TOP w0.112: SW3.2 292.19,126.02 v2(292.19,123.96) 292.19,122.78 SW3.4 ; v2(239.5,83.73) 239.5,82.48 v3(240,81.98) 240.54,81.44 242.51,81.44 242.86,81.09 242.86,80.05 CE10.1 RE33.2 ; JAPS1.11 v2(259.56,109.36)
  IN1 w0.119: v2(292.19,123.96) 292.19,123.77 291.17,122.76 289.65,122.76 289.25,123.15 289.25,124.55 285.9,127.9 258.96,127.9 253.16,122.09 253.16,115.37 258.36,110.16 258.75,110.16 v2(259.56,109.36) ; v2(239.5,83.73) 239.34,83.89 238.69,83.89 238.23,84.36 238.23,85.51 238,85.74 238,88.32 238.7,89.03 238.7,92.83 237.88,93.65 237.88,103.62 237.11,104.4 237.11,113.17 v2(237.74,113.8)
  BOTTOM w0.112: v2(259.56,109.36) 259.13,109.79 255.08,109.79 253.83,108.55 251.47,108.55 250.91,109.1 244.09,109.1 239.39,113.8 v2(237.74,113.8)
POWER_SW_IN#: length 15.4
  TOP w0.107: UE1.D5 v2(248.68,86.66)
  TOP w0.112: v1(242.35,78.13) 242.35,77.77 v2(242.53,77.6) 242.66,77.72 RE33.1 RE31.2 CE12.1
  IN1 w0.119: v2(248.68,86.66) 248.28,86.26 248.28,84.47 242.53,78.71 v2(242.53,77.6)
PRIM_PWRGD_GPIO024: length 6.6
  TOP w0.107: UE1.C1 248.28,83.53 247.52,82.76 v1(247.52,81.85) 247.52,79.05 RE362.1 RE361.1
PROCHOT#_ISL88738: length 16.6
  TOP w0.112: PU901.23 54.04,56.04 53.62,55.61 53.62,55.31 52.67,54.35 51.54,54.35 v1(51.47,54.42) v2(51.47,55.08) PR926.2
  IN2 w0.124: v2(58.85,51.42) 58.85,54.19 58.44,54.6 51.95,54.6 v2(51.47,55.08)
  BOTTOM w0.112: v2(58.85,51.42) 58.95,51.32 PQ1216.1
PS_ID: length 319
  TOP w0.107: UE1.L11 v2(255.08,92.26)
  TOP w0.112: PR5.2 PR4.1 44.4,120.61 44.65,120.36 44.65,118.3 v2(44.41,118.06)
  IN2 w0.124: v2(44.41,118.06) 43.71,118.76 42,118.76 39.01,121.74 39.01,122.59 39.37,122.95 39.74,122.95 41.64,124.84 46.28,124.84 47.52,126.07 48.96,126.07 50.19,124.84 60.77,124.84 62.74,126.81 67.66,126.81 68.22,127.37 74.75,127.37 75.01,127.11 79.84,127.11 83.34,130.61 103.76,130.61 104.53,131.38 108.75,131.38 109.62,130.51 117.37,130.51 118.62,131.76 124.15,131.76 124.94,130.97 124.94,130.55 125.21,130.28 126.22,130.28 126.88,130.95 129.88,130.95 130.76,131.82 134.31,131.82 136.42,133.93 143.47,133.93 144.32,133.08 145.27,133.08 148.23,130.12 154.96,130.12 155.47,130.63 156.48,130.63 158.64,128.47 158.64,123.64 161.82,120.47 161.82,119.71 162.44,119.09 162.44,110.31 167.13,105.62 167.13,90.63 169.45,88.32 169.45,85.76 171.81,83.4 171.81,80.78 181.62,70.97 185.19,70.97 186.91,69.25 206.27,69.25 207.53,67.99 221.9,67.99 222.58,68.67 225.7,68.67 226.29,69.26 227.85,69.26 230.98,72.38 232.7,72.38 234.01,73.7 234.93,73.7 235.69,74.45 235.69,75.4 236.36,76.08 236.36,76.69 237.01,77.34 238.53,77.34 239.12,76.75 244.25,76.75 245.73,75.27 249.26,75.27 249.64,74.89 250.42,74.89 251.23,75.7 252.75,75.7 253.56,76.51 257.75,76.51 259.2,75.07 260.68,75.07 262.13,76.52 262.13,79.89 261.92,80.1 261.92,82.51 261.67,82.76 259.64,82.76 257.52,84.88 257.52,85.92 256.85,86.59 256.85,90.49 v2(255.08,92.26)
PWM1_GT: length 11.2
  TOP w0.203: v2(53.54,92.7) 53.47,92.77 PU602.12
  TOP w0.254: PR680.1 v2(59.26,91.9)
  IN1 w0.254: v2(53.54,92.7) 53.96,92.7 55.14,91.51 58.88,91.51 v2(59.26,91.9)
  BOTTOM w0.203: v2(59.26,91.9) 59.21,91.84 59.21,90.43 59.48,90.16 59.95,90.16 60.1,90.31 PU612.8
PWM_IA: length 19.4
  TOP w0.112: v2(52.75,98.56) v1(53.28,98.56)
  TOP w0.203: v2(52.75,98.56) 52.17,97.98 52.17,97.75 51.53,97.11 PU602.22
  IN1 w0.254: v2(52.75,98.56) 53.21,99.02 53.21,101.26 54.51,102.55 v2(54.51,111.71)
  BOTTOM w0.203: v2(54.51,111.71) PR662.1 54.6,111.17 54.6,110.53 54.8,110.32 PU610.8
PWM_SA: length 2.3
  BOTTOM w0.112: v1(58.63,113.63) PR606.1
  BOTTOM w0.254: PU614.3 58.64,114.56 PR606.1
PWM_VSA: length 31.8
  TOP w0.203: v2(47.75,98) 47.85,98 48.33,97.52 PU602.30
  IN1 w0.254: v2(53.78,115.89) 49.41,115.89 47.12,113.59 47.12,107.83 48.18,106.77 48.18,103.98 46.8,102.6 46.8,101.39 47.14,101.05 47.14,98.54 47.67,98 v2(47.75,98)
  BOTTOM w0.112: v1(57.72,115.53) PR606.2
  BOTTOM w0.254: PR606.2 55.12,114.55 v2(53.78,115.89)
REM_DIODE1_N: length 204.8
  TOP w0.127: QE3.3 116.04,101.03 117.64,101.03 118.05,100.63 118.66,100.63 CE35.1 118.34,101.05 v2(118.33,101.03)
  TOP w0.254: UE1.A8 246.57,89.34 244.33,89.34 CE24.1 243.93,89.5 239.13,89.5 236.59,86.96 235.47,86.96 232.84,84.33 232.15,84.33 v2(232.11,84.36)
  IN3 w0.254: v2(118.33,101.03) 117.71,101.03 116.06,99.39 114.75,99.39 114.56,99.58 113.96,99.58 113.69,99.3 113.69,98.85 114.13,98.4 114.13,94.7 117.35,91.48 125.35,91.48 132.46,84.36 136.9,84.36 139.03,82.24 139.03,80.31 140.54,78.8 140.54,76.31 142.66,74.19 142.66,70.35 144.7,68.31 144.7,64.99 144.93,64.76 144.93,59.56 146.73,57.75 146.73,57.14 148.51,55.36 159.64,55.36 160.17,54.84 179.33,54.84 181.01,53.16 184.96,53.16 186.78,51.34 209.47,51.34 210.13,52.01 212.98,52.01 213.52,51.47 219.07,51.47 v2(219.61,52.01)
  BOTTOM w0.254: v2(219.61,52.01) 219.65,52.05 219.65,52.91 220.04,53.31 220.04,56.17 219.7,56.51 219.7,68.54 221.09,69.94 221.09,72.34 226.31,77.56 226.31,79.32 227.59,80.59 229.21,80.59 230.82,82.21 230.82,83.53 231.62,84.33 232.07,84.33 v2(232.11,84.36)
REM_DIODE1_P: length 206.9
  TOP w0.127: QE3.2 116.68,101.69 QE3.1 118.81,101.69 CE35.2 118.81,102.23 v2(118.47,102.23)
  TOP w0.254: UE1.A7 246.51,88.83 244.18,88.83 CE24.2 243.78,88.99 239.34,88.99 236.8,86.45 235.68,86.45 233.05,83.82 232.15,83.82 v2(232.11,83.78)
  IN3 w0.254: v2(220.19,52.01) 220.19,51.87 219.28,50.96 213.31,50.96 212.77,51.5 210.34,51.5 209.68,50.84 186.57,50.84 184.75,52.65 180.8,52.65 179.12,54.33 159.95,54.33 159.43,54.85 148.3,54.85 146.23,56.92 146.23,57.54 144.42,59.35 144.42,64.55 144.19,64.78 144.19,68.1 142.15,70.14 142.15,73.98 140.03,76.1 140.03,78.59 138.52,80.1 138.52,82.03 136.69,83.86 132.25,83.86 125.14,90.97 117.14,90.97 113.63,94.49 113.63,98.19 113.18,98.64 113.18,99.52 113.75,100.09 114.77,100.09 114.96,99.9 115.85,99.9 118.18,102.23 v2(118.47,102.23)
  BOTTOM w0.254: v2(220.19,52.01) 220.15,52.05 220.15,52.7 220.55,53.1 220.55,56.38 220.2,56.72 220.2,68.33 221.6,69.73 221.6,72.13 226.82,77.35 226.82,79.11 227.8,80.08 229.42,80.08 231.33,82 231.33,83.32 231.83,83.82 232.07,83.82 v2(232.11,83.78)
REM_DIODE2_N: length 149.4
  TOP w0.254: UE1.A10 246.52,90.89 243.29,90.89 CE26.1 242.9,90.88 v1(240.37,90.88) 238.7,90.88 v2(237.66,89.84) ; QE5.3 237,78.74 CE37.2 237.22,78.95 v2(237.77,78.95)
  IN1 w0.254: v2(237.66,89.84) 237.62,89.8 236.41,89.8 235.35,88.74 235.35,79.9 236.12,79.13 237.59,79.13 v2(237.77,78.95)
  IN3 w0.254: v2(155.45,53.33) 155.65,53.53 158.92,53.53 159.39,53.06 178.58,53.06 180.26,51.38 183.4,51.38 185.29,49.49 226.21,49.49 227.02,50.3 227.02,51.47 v2(227.06,51.51)
  BOTTOM w0.254: QE7.1 149.86,59.23 149.86,57.98 QE7.2 150.47,57.36 CE46.2 151.46,57.36 151.81,57.01 151.81,56.74 152.13,56.42 152.78,56.42 155.4,53.81 155.4,53.38 v2(155.45,53.33) ; v2(227.06,51.51) 227.05,51.52 227.05,52.03 227.4,52.39 228.95,52.39 229.69,51.65 232.19,51.65 232.91,52.38 232.91,53.47 234.68,55.24 234.68,56.46 237.76,59.54 237.76,60.59 237.46,60.89 237.46,62.98 237.18,63.26 237.18,65.74 236.82,66.1 236.82,78.72 237.14,79.04 237.68,79.04 v2(237.77,78.95)
REM_DIODE2_P: length 147.6
  TOP w0.254: v2(237.66,89.25) 237.79,89.25 238.91,90.37 242.9,90.37 CE26.2 243.32,90.38 246.56,90.38 UE1.A9 ; v2(237.77,79.64) 237.27,79.64 CE37.1 236.74,79.39 QE5.1 235.34,80.04 QE5.2
  IN1 w0.254: v2(237.66,89.25) 237.62,89.29 236.63,89.29 235.86,88.53 235.86,80.11 236.33,79.64 v2(237.77,79.64)
  IN3 w0.254: v2(154.86,53.33) 154.86,53.48 155.42,54.04 159.13,54.04 159.6,53.57 178.79,53.57 180.47,51.89 183.61,51.89 185.5,50 226,50 226.52,50.51 226.52,51.46 v2(226.48,51.5)
  BOTTOM w0.254: v2(154.86,53.33) 154.89,53.35 154.89,53.6 152.57,55.92 151.92,55.92 151.38,56.45 CE46.1 151.24,56.49 149.53,56.49 148.92,57.1 QE7.3 ; v2(226.48,51.5) 226.48,51.51 226.54,51.57 226.54,52.24 227.19,52.89 229.16,52.89 229.9,52.16 231.98,52.16 232.4,52.59 232.4,53.68 234.17,55.45 234.17,56.67 237.25,59.75 237.25,60.38 236.96,60.68 236.96,62.77 236.68,63.05 236.68,65.53 236.31,65.89 236.31,78.93 236.93,79.55 237.68,79.55 v2(237.77,79.64)
REM_DIODE4_N: length 232.6
  TOP w0.254: v2(142.84,77.42) 142.8,77.38 142.8,76.18 148.79,70.19 161.32,70.19 163.67,72.54 179.45,72.54 arc(181.96,71.21) 184.45,69.84 arc(187.68,68.53) 191.13,68.08 210.15,68.08 214.06,71.99 220.37,71.99 arc(222.69,72.46) 224.66,73.78 225.07,74.18 arc(226.55,76.43) 227.02,79.09 227.02,82.66 232.1,87.74 232.46,87.74 235.1,90.38 236.09,90.38 237.86,92.15 242,92.15 242.13,92.28 243.85,92.28 CE27.1 244.26,92.28 246.26,92.28 UE1.A11 ; v2(59.08,100.13) 59.02,100.19 58.71,100.19 58.49,99.98 58.49,84.47 v2(58.55,84.42)
  IN1 w0.254: v2(142.84,77.42) 142.8,77.38 142.8,76.67 141.88,75.75 87.75,75.75 81.08,82.42 73.86,82.42 73.06,83.22 70.81,83.22 69.9,82.31 61.26,82.31 59.15,84.42 v2(58.55,84.42)
  BOTTOM w0.102: QE6.3 v3(57.21,98.46)
  BOTTOM w0.254: QE6.3 57.4,99.96 CE39.1 58.52,100.13 v2(59.08,100.13)
REM_DIODE4_P: length 236
  TOP w0.127: UE1.B10 247.09,91.45 246.37,91.45
  TOP w0.254: v2(59.08,100.72) 59.05,100.7 58.49,100.7 57.99,100.19 57.99,84.47 v2(57.94,84.42) ; 246.37,91.45 246.05,91.77 244.26,91.77 CE27.2 243.85,91.77 242.34,91.77 242.21,91.64 238.07,91.64 236.3,89.88 235.31,89.88 232.67,87.23 232.31,87.23 227.53,82.45 227.53,79.1 arc(227.02,76.24) 225.43,73.82 225.02,73.42 arc(222.89,71.99) 220.37,71.49 214.27,71.49 210.36,67.57 191.13,67.57 arc(187.55,68.04) 184.2,69.39 arc(181.73,70.73) 179.24,72.03 163.88,72.03 161.53,69.68 148.58,69.68 142.29,75.97 142.29,77.38 v2(142.25,77.42)
  IN1 w0.254: v2(142.25,77.42) 142.29,77.38 142.29,76.88 141.67,76.25 87.96,76.25 81.29,82.93 74.07,82.93 73.27,83.73 70.6,83.73 69.69,82.81 61.47,82.81 59.36,84.93 58.34,84.93 57.94,84.53 v2(57.94,84.42)
  BOTTOM w0.254: v2(59.08,100.72) 58.51,100.72 CE39.2 57.4,100.87 QE6.2 55.96,101.07 QE6.1
RES_BIAS: length 4
  TOP w0.112: UL1.12 248.48,122.54 248.59,122.42 249.54,122.42 250.09,121.88 RL13.1 250.44,120.89 v1(251.05,120.89)
RESET_OUT#_R: length 3.7
  BOTTOM w0.112: RC128.2 RC129.2 89.38,127.16 CC33.1 89.71,128.36 JXDP1.47
RING2: length 41.4
  IN3 w1.016: 283.51,46.36 273.06,56.81 268.13,56.81 264.23,52.91 259.61,52.91 256.95,55.57 254.6,55.57 253.83,56.34 253.83,57.67 254.02,57.86 254.02,60.65
  vias: v1(252.86,61.81) v2(252.58,61.35) v2(253.16,61.35) v2(284.38,46.05) v2(284.38,45.48)
RING2_R:
  vias: v3(293.65,42.86)
RJ45_MDIN0: length 28.1
  IN3 w0.203: JLOM1.2 282.78,100.71 282.57,100.51 281.35,100.51 280.39,101.47 280.39,110.7 273.72,117.37 272.26,117.37 271.88,116.99 271.88,116.51 v2(271.75,116.39)
  BOTTOM w0.267: TL1.14 271.42,118.76 271.86,118.32 271.86,116.49 v2(271.75,116.39)
RJ45_MDIN1: length 32.5
  IN1 w0.203: JLOM1.6 282.92,105.14 282.92,104.44 282.57,104.09 281.15,104.09 279.79,105.45 279.79,110.45 275.44,114.81 268.96,114.81 268.57,114.41 268.57,113.87 v2(268.43,113.73)
  BOTTOM w0.267: v2(268.43,113.73) 268.53,113.83 268.53,114.48 267.85,115.16 266.13,115.16 264.25,117.05 264.25,118.15 263.8,118.59 TL1.20
RJ45_MDIN2: length 32
  IN3 w0.203: JLOM1.5 283.04,104.26 282.95,104.34 282.41,104.34 281.53,105.22 281.53,111.27 273.77,119.04 268.17,119.04 266.58,117.45 v2(266.58,116.39)
  BOTTOM w0.267: TL1.18 266.34,118.43 266.58,118.18 v2(266.58,116.39)
RJ45_MDIN3: length 36.5
  IN1 w0.203: v2(266.55,113.07) 266.67,113.2 266.67,113.99 268.53,115.85 276.11,115.85 280.96,110.99 280.96,107.38 281.71,106.63 282.57,106.63 282.78,106.83 JLOM1.8
  BOTTOM w0.267: TL1.24 258.72,118.53 259.15,118.1 259.15,117.2 262.36,113.99 266.28,113.99 266.65,113.63 266.65,113.17 v2(266.55,113.07)
RJ45_MDIP0: length 28.1
  IN3 w0.203: JLOM1.1 281.21,100.18 280.06,101.33 280.06,110.56 273.58,117.04 272.4,117.04 272.21,116.85 272.21,116.51 v2(272.34,116.39)
  BOTTOM w0.267: 272.69,119.57 272.69,118.76 272.24,118.3 272.24,116.49 v2(272.34,116.39)
RJ45_MDIP1: length 32.5
  IN1 w0.203: v2(269.01,113.73) 268.9,113.84 268.9,114.27 269.1,114.48 275.3,114.48 279.46,110.31 279.46,105.31 282.55,102.22 JLOM1.3
  BOTTOM w0.267: TL1.19 265.07,118.58 264.63,118.13 264.63,117.21 266.29,115.54 268.01,115.54 268.91,114.64 268.91,113.83 v2(269.01,113.73)
RJ45_MDIP2: length 31.9
  IN3 w0.203: v2(267.31,116.39) 266.91,116.78 266.91,117.31 268.31,118.71 273.63,118.71 281.2,111.14 281.2,105.08 282.27,104.01 282.75,104.01 283.01,103.76 283.01,103.47 JLOM1.4
  BOTTOM w0.267: v2(267.31,116.39) 266.97,116.73 266.97,118.04 267.14,118.22 267.46,118.22 267.61,118.37 TL1.17
RJ45_MDIP3: length 36.5
  IN1 w0.203: JLOM1.7 281.57,106.3 280.63,107.24 280.63,110.86 275.97,115.52 268.67,115.52 267,113.85 267,113.2 v2(267.13,113.07)
  BOTTOM w0.267: v2(267.13,113.07) 267.03,113.17 267.03,113.78 266.44,114.37 262.52,114.37 259.54,117.36 259.54,118.15 259.99,118.6 TL1.23
RTCRST_ON: length 6.4
  TOP w0.112: v1(244.63,99.9) RE93.1 245.6,100.13 245.25,100.48 QE12.2 245.25,101.98 245.03,102.2 245.03,103.67 RE514.2 RE515.2
RTCRST_ON_GPIO122: length 16.9
  TOP w0.112: v2(246.32,103.87) 246.63,104.19 246.63,104.9 v1(246.58,104.95) 246.39,105.14 245.85,105.14 RE515.1 ; UE1.F11 v2(250.28,92.26)
  IN3 w0.135: v2(250.28,92.26) 250.28,93.98 249.92,94.35 249.92,95.76 248.02,97.66 248.02,103.41 247.56,103.87 v2(246.32,103.87)
RTCRST_ON_GPIO141: length 18.3
  TOP w0.107: UE1.B6 v2(247.05,87.43)
  TOP w0.112: v2(245.89,101.75) 245.31,102.33 245.31,103.67 RE514.1
  IN1 w0.119: v2(247.05,87.43) 246.56,87.92 246.56,92.52 246.89,92.85 246.89,93.97 246.58,94.27 246.58,96.38 245.89,97.07 v2(245.89,101.75)
RTD3_CIO_PWR_EN: length 204.6
  TOP w0.112: v2(140.86,125.81) 140.86,126.07 140.65,126.27 139.5,126.27 138.47,127.3 135.93,127.3 134.57,128.65 134.57,130.73 132.58,132.73 127.4,132.73 v1(126.59,133.54) v2(125.65,134.48) ; v2(26.38,93.7) 27,93.08 RT392.2
  IN2 w0.124: v2(140.73,100.78) 141,100.78 142.52,102.3 142.52,107.89 139.06,111.35 139.06,112.08 138.73,112.41 138.73,117.31 140.31,118.89 140.31,122.13 139.35,123.09 139.35,124.02 140.86,125.53 v2(140.86,125.81) ; v2(26.38,93.7) 26.9,94.22 26.9,95.95 27.28,96.33 32.49,96.33 34.16,94.65 35.81,94.65 36.68,95.51 36.68,101.2 36.17,101.71 36.17,106.23 32.22,110.18 32.22,110.74 30.5,112.46 30.5,118.32 38.07,125.89 40.38,125.89 40.89,126.4 46.23,126.4 47.39,127.56 61.48,127.56 62.42,128.51 66.93,128.51 67.23,128.81 75.44,128.81 75.77,128.48 79.29,128.48 83.79,132.99 88.49,132.99 90.33,134.83 120.39,134.83 121.77,133.46 122.68,133.46 123.29,134.07 125.25,134.07 v2(125.65,134.48)
  BOTTOM w0.076: UC1.AC2 131.57,101.18 131.89,100.86 134.53,100.86 134.99,100.4 135.55,100.4
  BOTTOM w0.112: 135.55,100.4 138.26,100.4 138.77,100.91 140.5,100.91 140.63,100.78 v2(140.73,100.78) ; RT25.1 RT372.1 26.82,93.25 v2(26.38,93.7)
RTD3_CIO_PWR_EN_R: length 5.6
  TOP w0.076: UT1.F1 26.6,96.29 26.41,96.1 26.41,95.15 26.29,95.02 26.29,94.88
  TOP w0.112: RT392.1 27.06,91.82 27.47,92.23 27.47,93.27 26.29,94.45 26.29,94.88
RTD3_USB_PWR_EN: length 2.9
  TOP w0.102: UT1.D4 v2(25.79,98.04)
  BOTTOM w0.112: v2(25.79,98.04) 25.12,97.37 RT26.1 25.12,96.61 v1(24.57,96.07)
RUN_ON: length 341.6
  TOP w0.112: RE292.1 RE280.2 261.4,99.22 261.4,99.69 v2(261.39,99.71) ; v2(274.34,93.23) 273.27,94.3 273.18,94.34 270.13,94.34 269.7,94.78 269.7,95.26 268.86,96.1 268.3,96.1 267.55,96.85 265.94,96.85 UE5.4 v2(264.33,97.66) ; PR402.1 v2(144.68,127.47) 144.35,127.14 v1(144.14,127.14) ; UZ4.3 v2(279.91,90.54) ; RZ345.1 203.99,54.28 202.64,55.62 202.64,56.63 201.67,57.59 201.67,59.22 200.68,60.21 184.95,60.21 182.92,58.18 v2(182.9,58.18) ; v2(170.66,69.4) 170.38,69.68 165.28,69.68 162.71,67.12 161.01,67.12 157.71,63.82 v2(157.71,62.06) ; v2(159.41,60.63) 159.3,60.74 UZ3.5
  IN1 w0.119: v2(124.39,128.47) 125.08,127.78 129.95,127.78 130.15,127.58 140.11,127.58 140.42,127.9 144.25,127.9 v2(144.68,127.47) ; v2(242.98,73.16) 242.98,73.6 241.04,75.53 241.04,81.24 240.24,82.04 240.24,83.54 239.31,84.47 v2(238.67,84.47) 239.76,85.55 239.76,90.56 239.14,91.18 239.14,93.02 238.32,93.84 238.32,103.21 v2(243.01,107.9)
  IN2 w0.124: v2(243.01,107.9) 245.6,105.31 255.59,105.31 256.13,104.77 258.68,104.77 261.03,102.41 261.03,101.18 261.45,100.76 261.45,99.77 v2(261.39,99.71) ; v2(144.68,127.47) 145.61,126.54 146.87,126.54 147.86,125.54 154.12,125.54 158.91,120.75 158.91,118.86 161.09,116.69 161.09,109.67 164.01,106.74 164.01,105.87 164.9,104.99 164.9,90.95 168.08,87.76 168.08,85.2 170.43,82.86 170.43,79.81 171.98,78.25 171.98,74.23 v2(172.12,74.1) 175.89,74.1 180.38,69.61 184.63,69.61 186.36,67.88 205.56,67.88 206.89,66.55 225.82,66.55 227.17,67.9 231.73,67.9 231.88,67.76 232.68,67.76 233.59,68.67 234.64,69.73 236.06,69.73 236.52,70.18 239.38,70.18 240.3,71.09 240.3,72.54 241.61,73.85 242.29,73.85 v2(242.98,73.16) ; v2(182.9,58.18) 182.25,58.18 181.77,57.69 180.24,57.69 179.09,58.84 177.36,58.84 176.12,57.6 172.37,57.6 169.16,60.81 165.98,60.81 165.46,60.3 160.13,60.3 159.8,60.63 v2(159.41,60.63) 157.97,62.06 v2(157.71,62.06)
  IN3 w0.135: v2(172.12,74.1) 172.12,70.86 v2(170.66,69.4)
  BOTTOM w0.112: RZ320.1 v2(124.39,128.47) 125.01,129.09 125.01,129.85 124.74,130.12 UZ35.2 ; v2(264.33,97.66) 262.69,99.3 261.79,99.3 v2(261.39,99.71) ; v2(238.67,84.47) 238.47,84.47 238.21,84.21 QE2.2 ; v2(279.91,90.54) 279.91,90.58 277.27,93.23 v2(274.34,93.23)
RUN_ON#: length 3.3
  TOP w0.112: v2(238.62,85.1) 238.66,85.1 238.89,85.33 RE68.1 v1(239.32,84.39)
  BOTTOM w0.112: QE2.5 238.21,85.47 238.58,85.1 v2(238.62,85.1) 238.66,85.1 238.86,85.31 QE2.6
RUN_ON_EC: length 30.9
  TOP w0.112: UE1.E8 v2(249.48,89.86) ; v2(257.45,99.45) 257.66,99.66 259.96,99.66 260.18,99.43 RPE10.4 260.18,98.45 260.96,97.67 261.66,97.67 RE292.2 262.29,98.31 UE5.2 263.64,98.31 263.84,98.11 263.84,97.46 264.1,97.2 264.68,97.2 264.95,96.94 v1(264.95,96.61)
  BOTTOM w0.112: v2(257.45,99.45) 256.21,100.7 251.38,100.7 250.18,99.49 250.18,96.06 250.68,95.55 250.68,89.61 250.47,89.39 249.95,89.39 v2(249.48,89.86)
RUNPWROK: length 271.7
  TOP w0.112: v2(83.02,123.31) 83.4,122.93 v2(83.4,121.69) 82.74,121.69 v2(81.5,120.45) 81.03,119.98 79.8,119.98 79.45,120.33 79.45,123.32 81.72,125.6 84.53,125.6 v1(85.34,126.41) 86.87,127.94 v2(86.87,128.84) ; UE1.G3 v2(251.08,85.06)
  IN1 w0.119: v2(242.09,73.23) 242.09,73.76 240.48,75.36 240.48,80.79 239.55,81.73 239.55,82.24 v2(239.04,82.75)
  IN2 w0.124: v2(86.87,128.84) 87.83,127.87 89.36,127.87 89.81,128.33 103.87,128.33 104.18,128.65 108.42,128.65 108.92,129.15 118.14,129.15 118.34,129.35 122.54,129.35 122.97,128.92 126.72,128.92 126.92,128.71 131.01,128.71 131.49,128.23 138.96,128.23 139.38,128.65 140.17,128.65 140.73,128.09 143.09,128.09 144.89,126.29 146.73,126.29 147.71,125.31 153.96,125.31 158.68,120.59 158.68,118.77 160.21,117.24 160.21,109.7 160.58,109.33 161.1,109.33 163.79,106.64 163.79,105.78 164.57,105 164.57,90.96 167.86,87.67 167.86,85.11 170.2,82.77 170.2,79.71 171.69,78.23 171.69,73.9 171.88,73.71 175.93,73.71 180.25,69.39 184.53,69.39 186.3,67.63 205.46,67.63 206.76,66.32 225.92,66.32 227.27,67.67 231.51,67.67 231.65,67.53 232.77,67.53 234.74,69.5 236.15,69.5 236.61,69.96 239.49,69.96 240.54,71 240.54,72.39 241.37,73.23 v2(242.09,73.23) ; v2(239.04,82.75) 239.04,83.83 240.66,85.46 243.2,85.46 244.78,83.88 248.54,83.88 249.31,84.66 249.66,84.66 249.88,84.88 249.88,85.25 250.09,85.46 250.68,85.46 v2(251.08,85.06)
  BOTTOM w0.112: UC8.13 82.3,123.41 82.41,123.31 v2(83.02,123.31) 83.09,123.24 84.34,123.24 84.69,122.88 85.17,122.88 85.49,123.2 85.49,123.7 83.18,126 81.51,126 80.8,125.3 UC8.10 ; v2(81.5,120.45) 81.3,120.65 UC8.4 ; RE67.1 236.24,83.48 236.83,83.48 237.18,83.83 QE2.3 237.79,83.61 237.79,82.63 238.03,82.38 238.67,82.38 v2(239.04,82.75) ; UC8.1 83.21,122.3 83.4,122.12 v2(83.4,121.69)
SA_LGATE: length 8
  IN3 w0.508: v2(62.2,115.53) 64.9,115.53 65.84,116.47 v2(68.67,116.47)
  BOTTOM w0.102: v2(62.2,115.53) 62.71,115.53 62.83,115.64 v3(62.83,116.15)
SA_SNUB: length 1.8
  TOP w0.112: PR627.2 v1(66.13,112.71)
SA_SW: length 8.1
  IN3 w0.508: v2(68.81,115.68) 68.81,114.79 67.26,113.24 63.4,113.24 v2(63.27,113.37)
  BOTTOM w0.102: 69.43,113.99 v3(69.43,112.98)
SA_UGATE: length 10.3
  IN3 w0.508: v2(59.28,113.45) 61.02,113.45 61.89,112.58 67.87,112.58 v2(68.22,112.94)
  BOTTOM w0.112: v1(68.16,112.09) 68.22,112.15 v2(68.22,112.94)
SATA_LED_EN: length 17.9
  TOP w0.112: v2(273.77,83.89) QZ2.5 ; v1(267.56,96.02) 267.87,95.72 v2(267.87,95.58) 267.75,95.46 UE2.14
  IN1 w0.119: v2(267.87,95.58) 268.69,94.75 269.58,94.75 270.28,94.05 271.93,94.05 273.14,92.85 273.14,84.53 v2(273.77,83.89)
SATALED#: length 390.2
  TOP w0.112: v2(262.33,75.28) 262.37,75.25 263.62,75.25 266.85,78.47 270.78,78.47 272.88,80.57 QZ2.4 ; RN100.2 v1(25.17,55.71) 25.17,58.79 24.13,59.83 24.13,61.72 24.78,62.37 25.88,62.37 33.76,70.24 v2(35.39,70.24) ; v2(39.86,108.71) 40.18,109.03 v2(40.18,110.63)
  IN2 w0.124: v2(262.33,75.28) 261.58,75.28 259.99,73.7 258.42,73.7 258.03,74.09 253.26,74.09 252.08,72.91 249.16,72.91 248.96,72.71 244.15,72.71 242.66,71.22 242.13,71.22 240.14,69.23 236.91,69.23 236.46,68.77 235.14,68.77 232.76,66.38 230.97,66.38 230.45,66.91 227.54,66.91 226.17,65.54 206.07,65.54 204.72,66.89 186,66.89 184.23,68.66 179.94,68.66 175.62,72.98 171.58,72.98 170.96,73.59 170.96,77.92 169.47,79.41 169.47,82.39 167.1,84.75 167.1,87.37 163.41,91.06 156.12,91.06 154.24,92.94 154.24,97.1 150.06,101.28 150.06,104.57 149.53,105.11 149.53,105.6 149.78,105.85 149.78,107.46 151.69,109.37 151.69,110.96 v2(150.91,111.73) ; v2(39.86,108.71) 39.86,107.34 40.49,106.72 40.49,104.43 39.78,103.72 39.78,102.58 40.82,101.53 40.82,100.7 41.6,99.91 41.6,98.92 40.79,98.11 40.79,87.51 38.63,85.35 38.63,80.96 36.84,79.17 36.84,73.15 35.39,71.7 v2(35.39,70.24) ; v2(40.18,110.63) 40.51,110.63 45.11,115.22 45.11,118.33 44.19,119.24 42.34,119.24 40.71,120.86 40.71,122.6 41.15,123.04 46.65,123.04 47.24,123.63 53.65,123.63 55.96,121.32 59.31,121.32 62.85,124.86 68.55,124.86 68.99,125.3 70.75,125.3 71.19,124.85 71.98,124.85 72.08,124.95 72.65,124.95 74.19,123.4 81.89,123.4 83.11,124.62 85.44,124.62 85.81,124.26 91.07,124.26 91.82,125 93.06,125 93.45,124.62 97.28,124.62 98.27,125.61 104.29,125.61 104.68,126.01 111.39,126.01 111.88,126.5 120.22,126.5 120.62,126.9 121.57,126.9 122.59,125.89 133.1,125.89 133.94,125.05 133.94,121.34 133.5,120.91 133.5,119.41 134.78,118.13 134.78,111.63 134.01,110.86 v2(134.01,110.27)
  BOTTOM w0.076: UC1.H1 132.15,109.21 132.78,109.21 133.84,110.27
  BOTTOM w0.112: 133.84,110.27 v2(134.01,110.27) 140.04,110.27 140.92,109.71 144.61,109.71 145.14,110.24 RPC4.3 146.75,110.24 146.97,110.46 146.97,110.96 147.4,111.39 148.54,111.39 148.88,111.73 v2(150.91,111.73)
SBIOS_TX: length 230.3
  TOP w0.112: v2(146.56,92.97) 146.91,92.62 147.56,92.62 149.4,90.78 160.82,90.78 161.09,91.04 164.61,91.04 167.02,88.64 v2(167.02,80.86) ; v2(228.42,86.12) 229.14,86.12 234.13,91.11 235.83,91.11 237.7,92.97 239.58,92.97 240.39,93.79 242.36,93.79 v2(242.72,93.43)
  IN1 w0.097: v2(146.56,92.97) 146.56,93.08 143.87,95.76 142.42,95.76 141.97,96.21 141.97,96.32 141.44,96.85 140.42,96.85 136.57,100.7 133.75,100.7 v2(133.07,101.38)
  IN1 w0.119: v2(216.01,73.78) 216.01,73.78 216.04,73.75 221.85,73.75 223.75,75.65 223.75,81.14 226.27,83.67 226.27,85.16 227.23,86.12 v2(228.42,86.12) ; v2(289.9,122.31) 291.24,122.31 292.63,123.71 292.63,125.17 287.87,129.93 257.94,129.93 251.18,123.17 251.18,117.49 250.19,116.5 250.19,115.94 248.39,114.13 246.89,114.13 246.17,113.42 246.17,110.43 246.58,110.02 246.58,106.32 244.94,104.68 244.94,99.87 243.97,98.9 243.97,94.21 243.19,93.43 v2(242.72,93.43)
  BOTTOM w0.076: UC1.AB2 132.2,101.62 132.83,101.38 v2(133.07,101.38)
  BOTTOM w0.112: v2(216.01,73.78) 215.87,73.64 215.87,73.49 211.42,69.04 185.06,69.04 173.24,80.86 v1(170.2,80.86) v2(167.02,80.86) ; RE306.1 v2(289.9,122.31)
SD/MMCCD#: length 26.9
  TOP w0.112: UR1.30 274.67,67.39 v2(274.27,67.79) ; JSD1.9 284.28,51.47 v2(283.63,52.13)
  IN1 w0.119: v2(274.27,67.79) 274.88,67.18 274.88,63.8 279.95,58.74 281.23,58.74 283.13,56.84 285.18,56.84 285.7,56.32 285.7,54.21 v2(283.63,52.13)
SD/MMCCLK: length 4.3
  TOP w0.112: UR1.17 277.66,63.47 277.82,63.31 277.82,61.89 278.18,61.53 278.18,60.39 RR5.1
SD/MMCCLK_R: length 23.5
  TOP w0.112: v2(283.63,55.38) 284.02,55.77 JSD1.5 ; v2(279.2,57.95) 278.69,57.95 CR21.1 278.54,58.86 RR5.2
  IN1 w0.119: v2(283.63,55.38) 284.64,56.4 285.02,56.4 285.28,56.14 285.28,54.4 285.01,54.13 284.41,54.13 284.29,54.25 284.29,54.92 284.17,55.04 283.86,55.04 283.73,54.91 283.73,54.25 283.61,54.13 283.3,54.13 283.17,54.25 283.17,56.13 283.05,56.25 282.55,56.25 282.43,56.37 282.43,56.91 282.29,57.06 282,57.06 281.89,56.94 281.89,55.22 281.77,55.1 281.45,55.1 281.33,55.22 281.33,56.94 281.21,57.06 281.07,57.06 280.95,57.18 280.95,57.49 280.83,57.61 280.48,57.61 280.36,57.49 280.36,57.25 280.24,57.14 279.96,57.14 279.84,57.25 279.84,57.7 279.69,57.86 279.28,57.86 v2(279.2,57.95)
SD/MMCCMD: length 5.9
  TOP w0.112: RR6.1 279.17,61.21 279.17,63.84 278.74,64.27 UR1.19
SD/MMCCMD_R: length 27.4
  TOP w0.112: JSD1.3 290.76,57.57 v2(291.24,58.05) ; RR6.2 280.96,60.32 281.38,59.9 282.07,59.9 282.38,59.59 v2(283.03,59.59)
  IN1 w0.119: v2(291.24,58.05) 290.54,58.05 290.33,58.25 290.33,60.76 290.21,60.88 289.97,60.88 289.86,60.76 289.86,58.18 289.74,58.06 289.5,58.06 289.38,58.18 289.38,60.79 289.26,60.91 289.02,60.91 288.9,60.79 288.9,58.26 288.76,58.11 288.44,58.11 287.23,59.32 284.31,59.32 283.88,59.75 283.19,59.75 v2(283.03,59.59)
SD/MMCDAT0/RCLK+: length 2.1
  TOP w0.089: UR1.16 276.67,62.43 277.33,61.77 277.33,61.56 RR10.1
SD/MMCDAT0/RCLK+_R: length 29.8
  TOP w0.089: JSD1.7 285.42,53.97 284.9,53.45 283.79,53.45 v2(283.63,53.62) ; RR10.2 277.39,59.94 277.39,59.47 v2(277.56,59.3)
  IN1 w0.089: v2(277.56,59.3) 277.32,59.06 277.32,58.8 277.47,58.64 278.53,58.64 278.71,58.46 278.71,58 278.51,57.79 276.86,57.79 276.76,57.69 276.76,57.41 276.87,57.29 279.01,57.29 279.22,57.08 279.22,56.63 279.02,56.42 276.32,56.42 276.2,56.31 276.2,55.99 276.35,55.84 279.04,55.84 279.25,55.64 279.25,53.82 279.33,53.73 279.77,53.73 279.86,53.82 279.86,55.98 280.07,56.2 280.62,56.2 280.83,55.99 280.83,53.56 281.08,53.31 283.33,53.31 283.63,53.61 v2(283.63,53.62)
SD/MMCDAT1/RCLK-: length 2.1
  TOP w0.089: UR1.15 276.27,62.47 277.07,61.67 277.07,61.43 RR9.1
SD/MMCDAT1/RCLK-_R: length 29.9
  TOP w0.089: v2(276.97,59.3) 277.14,59.47 277.14,59.94 RR9.2 ; JSD1.8 285.02,53.07 284.9,53.2 283.79,53.2 v2(283.63,53.03)
  IN1 w0.089: v2(283.63,53.03) 283.55,53.11 280.99,53.11 280.62,53.48 280.62,55.9 280.54,55.99 280.16,55.99 280.07,55.9 280.07,53.74 279.86,53.53 279.25,53.53 279.04,53.73 279.04,55.55 278.96,55.63 276.27,55.63 276,55.91 276,56.4 276.23,56.63 278.93,56.63 279.02,56.71 279.02,57 278.93,57.09 276.79,57.09 276.55,57.32 276.55,57.77 276.78,58 278.29,58 278.29,58 278.42,58 278.53,58.11 278.53,58.35 278.44,58.44 277.38,58.44 277.11,58.71 277.11,59.16 v2(276.97,59.3)
SD/MMCDAT2: length 5.4
  TOP w0.112: RR8.1 v1(280.05,63.07) 280.05,64.29 279.07,65.26 277.98,65.26 277.78,65.07 UR1.21
SD/MMCDAT2_R: length 23
  TOP w0.112: v2(284.89,60.21) 284.89,59.64 285.15,59.37 JSD1.1 ; RR8.2 282.21,60.87 283.07,60.87 v1(283.32,61.12) v2(283.68,61.48)
  IN1 w0.119: v2(284.89,60.21) 285.14,60.21 285.27,60.34 285.27,64.74 285.14,64.87 284.81,64.87 284.69,64.75 284.69,60.91 284.57,60.78 284.31,60.78 284.19,60.91 284.19,64.72 284.06,64.84 283.76,64.84 283.62,64.7 283.62,61.54 v2(283.68,61.48)
SD/MMCDAT3: length 5.7
  TOP w0.112: UR1.20 277.79,64.67 277.87,64.76 278.95,64.76 v1(279.16,64.55) 279.6,64.11 279.6,61.67 RR7.1
SD/MMCDAT3_R: length 28
  TOP w0.112: JSD1.2 290.03,58.47 290.24,58.68 v2(291.24,58.68) ; v2(283.04,60.18) 282.84,60.39 v1(281.98,60.39) 281.8,60.39 RR7.2
  IN1 w0.119: v2(291.24,58.68) 291.24,62.18 291.04,62.37 287.42,62.37 287.3,62.25 287.3,61.98 287.42,61.86 289.21,61.86 289.36,61.72 289.36,61.48 289.24,61.36 287.42,61.36 287.3,61.24 287.3,60.91 287.45,60.76 288.26,60.76 288.38,60.64 288.38,59.89 288.25,59.76 284.5,59.76 284.09,60.18 v2(283.04,60.18)
SD_GPIO: length 2.9
  TOP w0.112: RR3.2 274,68.38 v1(274.7,68.38) 274.89,68.38 275.47,67.79 UR1.28
SD_RCOMP: length 3.8
  TOP w0.381: v2(129.3,102.71) 129.3,102.98 129.73,103.4 v1(129.77,103.4) 131.13,103.4 131.55,102.98 RC96.1
  BOTTOM w0.254: UC1.AB7 129.3,102.4 v2(129.3,102.71)
SD_UHS2_D0N: length 31.9
  TOP w0.089: UR1.25 276.67,67.39 v2(277.01,67.73) ; JSD1.19 298.47,55.19 297.87,55.79 291.55,55.79 v2(291.39,55.63)
  IN1 w0.089: v2(291.39,55.63) 291.2,55.81 288.86,55.81 286.56,58.11 283.58,58.11 282.35,59.35 282.35,64.05 278.18,68.21 276.98,68.21 276.82,68.05 276.82,67.92 v2(277.01,67.73)
SD_UHS2_D0P: length 31.9
  TOP w0.089: UR1.26 276.27,67.58 v2(276.41,67.73) ; JSD1.18 298.14,56.1 298.08,56.04 291.55,56.04 v2(291.39,56.21)
  IN1 w0.089: v2(291.39,56.21) 291.2,56.02 288.95,56.02 286.65,58.32 283.66,58.32 282.55,59.43 282.55,64.13 278.27,68.42 276.89,68.42 276.61,68.13 276.61,67.92 v2(276.41,67.73)
SD_UHS2_D1N: length 31.9
  TOP w0.089: v2(278.45,66.27) 278.29,66.27 277.89,65.87 UR1.23 ; JSD1.21 298.7,53.37 298.27,52.94 297.96,52.94 v2(297.89,52.87)
  IN1 w0.089: v2(278.45,66.27) 278.56,66.15 279.39,66.15 281.73,63.81 281.73,59.11 283.35,57.49 285.95,57.49 290.15,53.3 291.88,53.3 291.97,53.38 291.97,53.62 292.18,53.83 292.62,53.83 292.83,53.62 292.83,53.38 292.91,53.3 293.18,53.3 293.27,53.38 293.27,53.65 293.48,53.86 293.92,53.86 294.13,53.65 294.13,53.38 294.22,53.3 294.82,53.3 295.32,52.79 297.81,52.79 v2(297.89,52.87)
SD_UHS2_D1P: length 31.9
  TOP w0.089: v2(297.89,52.28) 298.07,52.46 JSD1.22 ; UR1.22 277.8,65.47 278,65.67 v2(278.45,65.67)
  IN1 w0.089: v2(278.45,65.67) 278.72,65.95 279.3,65.95 281.52,63.73 281.52,59.03 283.26,57.29 285.86,57.29 290.06,53.09 291.97,53.09 292.18,53.3 292.18,53.54 292.26,53.63 292.53,53.63 292.62,53.54 292.62,53.3 292.83,53.09 293.27,53.09 293.48,53.3 293.48,53.56 293.56,53.65 293.83,53.65 293.92,53.56 293.92,53.3 294.13,53.09 294.74,53.09 295.24,52.59 297.59,52.59 v2(297.89,52.28)
SDWP: length 13.5
  TOP w0.112: UR1.29 275.07,67.61 v2(274.89,67.79) ; v2(280.63,59.31) QR1.1
  IN1 w0.119: v2(280.63,59.31) 280.63,59.69 279.52,60.79 278.49,60.79 275.66,63.62 275.66,67.02 v2(274.89,67.79)
SHD_CLK: length 20
  TOP w0.107: UE1.J8 v2(253.48,89.86)
  TOP w0.112: v2(253.26,101.48) 253.26,102.25 252.67,102.84 251.99,102.84 v1(251.82,103.01) 251.7,103.13 251.7,103.66 RE374.1
  IN1 w0.119: v2(253.26,101.48) 253.97,100.77 254.25,100.77 254.74,100.29 254.74,96.63 254.09,95.98 254.09,94.87 254.38,94.58 254.38,93.84 255.5,92.72 255.5,90.31 255.48,90.3 255.48,89.71 255.2,89.42 253.92,89.42 v2(253.48,89.86)
SHD_CLK_R1: length 38.2
  TOP w0.112: v2(244.21,117.09) 244.2,117.1 242.73,117.1 242.62,116.99 242.62,116.58 242.73,116.46 243.55,116.46 243.66,116.35 243.66,116.13 243.55,116.02 242.68,116.02 242.57,115.9 242.57,115.68 242.68,115.57 243.55,115.57 243.66,115.46 243.66,115.23 243.55,115.12 v1(243.15,115.12) 242.71,115.12 242.59,115.01 242.59,114.73 242.71,114.62 243.93,114.62 244.04,114.73 244.04,114.95 244.15,115.06 244.38,115.06 244.49,114.95 244.49,114.73 244.6,114.62 244.83,114.62 244.94,114.73 244.94,114.95 245.05,115.06 245.27,115.06 245.38,114.95 245.38,114.73 245.5,114.62 245.72,114.62 245.83,114.73 245.83,114.95 245.94,115.06 246.17,115.06 246.28,114.95 246.28,114.73 246.39,114.62 246.61,114.62 246.73,114.73 246.73,114.95 246.84,115.06 247.06,115.06 247.17,114.95 247.17,114.73 247.28,114.62 247.51,114.62 247.62,114.73 247.62,114.95 247.73,115.06 247.95,115.06 248.07,114.95 248.07,114.73 248.18,114.62 249.51,114.62 249.72,114.83 253.2,114.83 255.1,112.93 255.1,112.34 254.34,111.58 254.34,108.56 253.14,107.35 253.14,106.89 252.06,105.81 RE374.2
  BOTTOM w0.112: UE9.6 243.67,120.53 243.95,120.26 243.95,117.8 244.21,117.54 v2(244.21,117.09)
SHD_CS#: length 60.4
  TOP w0.107: 257.22,86.66 255.88,86.66 UE1.M5
  TOP w0.112: 257.22,86.66 257.86,86.02 258.11,86.02 258.7,85.43 258.7,84.59 259.17,84.12 RE364.1 259.76,84.22 260.13,84.59 261.06,84.59 261.42,84.95 v2(261.42,85.33) 261.89,85.33 RE98.1
  IN1 w0.119: v2(252.82,113.99) 253.77,113.99 257.4,110.36 257.4,108.52 263.87,102.06 263.87,99.39 263.17,98.69 263.17,96.59 262.5,95.92 262.5,86.41 v2(261.42,85.33)
  BOTTOM w0.112: UE9.1 250.81,123.07 250.93,122.96 250.93,122.13 251.04,122.02 251.28,122.02 251.4,122.13 251.4,123.18 251.51,123.29 251.79,123.29 251.9,123.18 251.9,122.26 252.01,122.15 252.26,122.15 252.37,122.26 252.37,123.17 252.48,123.28 252.76,123.28 252.87,123.17 252.87,114.04 v2(252.82,113.99)
SHD_IO0: length 71.9
  TOP w0.107: UE1.J7 v2(253.48,88.26)
  TOP w0.112: RE366.1 v1(252.96,103.96) 252.96,103.19 253.58,102.56 253.58,101.76 v2(253.85,101.49)
  IN1 w0.119: v2(253.85,101.49) 254.99,100.35 254.99,96.53 254.35,95.9 254.35,94.98 254.66,94.68 254.66,93.99 255.75,92.9 255.75,90.87 256.31,90.31 256.31,89.73 255.4,88.82 254.05,88.82 v2(253.48,88.26) ; v2(245.71,112.11) 244.59,110.99 244.59,104.88 242.77,103.07 242.77,100.77 v2(243.94,99.6)
  BOTTOM w0.112: v2(243.94,99.6) 244.63,100.29 250.68,100.29 251.29,100.91 253.24,100.91 253.82,101.49 v2(253.85,101.49) ; QE13.5 237.86,131.9 237.37,131.42 RE530.1 CE503.1 237.37,125.57 241.13,121.82 241.13,118.18 240.6,117.65 240.6,115.29 244.15,111.75 245.34,111.75 v2(245.71,112.11)
SHD_IO0_R1: length 24.4
  TOP w0.112: RE367.1 252.83,115.4 253.06,115.63 253.68,115.63 253.82,115.49 253.82,114.91 253.93,114.79 254.15,114.79 v1(254.19,114.83) 254.27,114.91 254.27,115.52 254.38,115.63 254.6,115.63 254.71,115.52 254.71,114.01 254.82,113.9 255.05,113.9 255.16,114.01 255.16,115.52 255.27,115.63 255.54,115.63 255.65,115.52 255.65,114.16 255.76,114.04 256.22,114.04 256.34,113.93 256.34,113.71 256.22,113.6 255.74,113.6 255.62,113.49 255.62,113.26 255.74,113.15 256.22,113.15 256.34,113.04 256.34,112.82 256.22,112.7 255.74,112.7 255.62,112.59 255.62,112.37 255.74,112.26 256.22,112.26 256.34,112.14 256.34,111.92 256.22,111.81 255.74,111.81 255.62,111.7 255.62,111.47 255.74,111.36 256.22,111.36 256.34,111.25 256.34,111.03 256.22,110.92 255.74,110.92 255.62,110.8 255.62,110.58 255.74,110.47 256.17,110.47 256.28,110.36 256.28,110.13 256.17,110.02 255.02,110.02 254.83,109.84 254.83,108.34 253.67,107.17 253.67,106.61 RE366.2
SHD_IO0_R2: length 12.1
  TOP w0.112: RE367.2 v2(251.05,115.33)
  BOTTOM w0.112: v2(251.05,115.33) 245.39,115.33 v2(245.12,115.6) 243.46,117.26 243.46,119.15 243.35,119.26 UE9.5
SHD_IO1: length 20.8
  TOP w0.107: UE1.L6 v2(255.08,87.46)
  TOP w0.112: RE368.1 254.28,104.56 v1(254.28,103.94) 254.02,103.68 v2(254.02,102.1)
  IN1 w0.119: v2(255.08,87.46) 255.45,87.82 256.04,87.82 256.77,88.54 256.77,90.58 256.26,91.09 256.26,93.31 255.5,94.07 255.5,100.95 254.35,102.1 v2(254.02,102.1)
SHD_IO1_R1: length 24.5
  TOP w0.112: RE368.2 254.13,106.18 254.13,107.28 255.05,108.2 255.05,108.81 255.16,108.92 255.44,108.92 255.55,109.04 255.55,109.26 255.44,109.37 255.16,109.37 255.05,109.48 255.05,109.7 255.16,109.81 256.26,109.81 256.55,110.1 256.55,111.7 256.66,111.81 258.88,111.81 258.99,111.92 258.99,112.19 258.88,112.3 256.66,112.3 256.55,112.42 256.55,112.65 256.66,112.76 258.05,112.76 258.16,112.87 258.16,113.15 258.05,113.26 256.66,113.26 256.55,113.37 256.55,113.63 256.66,113.74 257.15,113.74 257.26,113.85 257.26,114.1 257.15,114.21 256.66,114.21 256.55,114.32 256.55,114.92 255.26,116.22 v1(254.35,116.22) RE369.1
SHD_IO1_R2: length 12
  TOP w0.112: RE369.2 v2(251.05,116.22)
  BOTTOM w0.112: v2(251.05,116.22) 252.04,115.23 252.48,115.23 252.59,115.34 252.59,121.69 252.48,121.8 UE9.2
SHD_IO2: length 31.5
  TOP w0.107: UE1.L7 v2(255.08,88.26)
  TOP w0.112: v1(257.23,104.54) 256.77,104.54 RE370.1 256.18,102.83 254.82,101.47 v2(254.43,101.47) ; RE360.1 261.83,81.33 v2(261.48,81.68)
  IN1 w0.119: v2(255.08,88.26) 255.15,88.26 256.54,89.65 256.54,90.43 256.01,90.97 256.01,93.08 255.01,94.07 255.01,94.71 254.61,95.11 254.61,95.74 255.24,96.38 255.24,100.65 v2(254.43,101.47)
  IN2 w0.124: v2(255.08,88.26) 255.52,87.82 255.52,86.03 259.87,81.68 v2(261.48,81.68)
SHD_IO2_R1: length 25.8
  TOP w0.112: RE370.2 RE376.1 256.68,106.23 256.68,106.97 256.35,107.3 255.98,107.3 255.68,107.61 255.68,108.5 256.4,109.23 256.89,109.23 257.07,109.42 257.07,109.92 257.18,110.03 259.49,110.03 259.6,110.14 259.6,110.41 259.49,110.53 257.15,110.53 257.03,110.64 257.03,110.91 257.15,111.02 259.47,111.02 259.59,111.15 259.59,112.6 v1(254.2,117.99) 254,118.2 RE371.1
SHD_IO2_R2: length 13.1
  TOP w0.112: v2(250.72,117.87) 251.05,118.2 RE371.2
  BOTTOM w0.112: UE9.3 250.78,120.53 250.89,120.65 250.89,121.01 251,121.12 251.25,121.12 251.36,121.01 251.36,120.19 251.47,120.08 251.72,120.08 251.83,120.19 251.83,121.01 251.94,121.12 252.19,121.12 252.3,121.01 252.3,117.98 252.19,117.87 251.91,117.87 251.8,117.98 251.8,119.05 251.69,119.16 251.41,119.16 251.29,119.05 251.29,117.98 251.18,117.87 v2(250.72,117.87)
SHD_IO3: length 19.8
  TOP w0.107: UE1.M6 v2(255.93,87.41)
  TOP w0.112: v2(254.9,102.1) v1(255.85,103.04) 255.85,103.41 RE372.1
  IN1 w0.119: v2(254.9,102.1) 255.7,102.1 256.63,101.17 256.63,95.96 256.49,95.82 256.49,91.25 257,90.74 257,88.28 256.13,87.41 v2(255.93,87.41)
SHD_IO3_R1: length 25.6
  TOP w0.112: RE373.1 250.56,116.7 250.98,116.7 251.09,116.81 251.09,117.34 251.2,117.45 251.54,117.45 251.65,117.34 251.65,116.86 251.76,116.75 252.01,116.75 252.12,116.86 252.12,117.35 252.23,117.46 252.51,117.46 252.62,117.35 252.62,116.86 252.74,116.75 252.96,116.75 253.1,116.89 v1(253.1,117.19) 253.1,117.34 253.21,117.45 253.53,117.45 253.63,117.35 253.63,116.81 253.76,116.68 255.2,116.68 259.38,112.5 259.38,111.49 259.27,111.38 256.87,111.38 256.76,111.27 256.76,109.89 255.36,108.49 255.36,108.15 254.71,107.5 254.71,106.32 RE377.1 RE372.2
SHD_IO3_R2: length 12.7
  TOP w0.112: RE373.2 249.87,115.57 249.85,115.55 245.75,115.55 245.21,116.09 v2(245.21,116.93)
  BOTTOM w0.112: UE9.7 243.43,121.8 245.01,120.23 245.01,117.49 245.21,117.28 v2(245.21,116.93)
SIM_DET: length 88.8
  TOP w0.112: v1(270.41,68.17) 270.15,67.92 v2(270.15,67.37)
  IN3 w0.135: v2(270.15,67.37) 270.15,68.01 270.74,68.59 279.89,68.59 280.86,67.63 v2(280.86,66.53)
  BOTTOM w0.112: JNGFF2.58 239.28,95.5 240.18,96.4 240.18,100.55 241.94,102.31 244.37,102.31 245.97,100.72 250.44,100.72 251.11,101.38 252.25,101.38 253.62,102.76 261.04,102.76 261.48,102.32 262,102.32 262.87,101.45 263.89,101.45 264.02,101.58 265.16,101.58 265.89,100.85 265.89,98.41 267.12,97.18 268.5,97.18 269.64,96.04 269.64,94.62 270.25,94.01 270.25,85.8 270.99,85.06 270.99,68.98 270.15,68.15 v2(270.15,67.37) ; v2(280.86,66.53) 280.69,66.37 280.69,65.14 281.02,64.81 JSIM1.2
SIO_EXT_SCI#: length 169.5
  TOP w0.112: v2(139.26,96.66) 137.98,95.38 134.41,95.38 134.35,95.32 131.89,95.32 130.64,96.57 v1(130.12,96.57) 128.85,96.57 v2(128.36,96.08) ; RE341.1 258.98,77.98 v2(258.98,77.53)
  IN2 w0.124: v2(258.85,72.4) 258.46,72.79 258.05,72.79 257.96,72.88 256.66,72.88 256.3,72.52 252.97,72.52 252.32,71.87 249.7,71.87 249.06,71.22 245.58,71.22 244.99,70.63 243.68,70.63 243.13,70.09 242.61,70.09 240.19,67.66 240.19,67.14 239.96,66.91 237.65,66.91 235.95,65.21 230.5,65.21 229.93,65.78 228.01,65.78 226.61,64.37 205.11,64.37 203.74,65.75 185.54,65.75 183.76,67.53 179.48,67.53 175.16,71.85 170.25,71.85 169.13,72.97 169.13,78.15 168.34,78.94 168.34,81.92 165.97,84.29 165.97,86.87 164,88.84 160.94,88.84 160.3,89.49 153.48,89.49 152.32,90.65 150.12,90.65 149.33,91.44 149.33,93.22 149.6,93.48 149.6,95.39 149.15,95.84 149.15,97.07 148.8,97.42 147.39,97.42 146.27,98.54 144.86,98.54 143.21,96.9 142.51,96.9 142.09,96.48 142.09,95.95 141.81,95.67 140.26,95.67 v2(139.26,96.66)
  BOTTOM w0.076: v2(128.36,96.08) 128.52,96.08 UC1.AN7
  BOTTOM w0.107: v2(139.26,96.66) 139.31,96.71 RC237.1
  BOTTOM w0.112: v2(258.85,72.4) 259.04,72.59 259.04,75.97 258.88,76.13 258.88,77.43 v2(258.98,77.53)
SIO_EXT_SCI#_EC: length 6.3
  TOP w0.112: UE1.M1 255.48,83.2 256.26,82.42 256.48,82.42 v1(256.51,82.39) 257.81,81.09 257.81,80.49 258.79,79.51 RE341.2
SIO_EXT_SMI#: length 195.9
  TOP w0.112: v2(261.58,77.86) 261.95,77.86 262.84,76.97 263.68,76.97 264.53,77.83 264.53,81.59 263.82,82.31 RE338.1
  IN2 w0.124: v2(161.48,123.44) 163.8,121.12 163.8,111.05 168.76,106.09 168.76,90.95 170.8,88.91 170.8,86.32 173.18,83.94 173.18,81.72 182.57,72.33 185.75,72.33 187.43,70.65 207.01,70.65 208.02,69.63 220.57,69.63 221.94,71 221.94,71.61 222.76,72.43 226.65,72.43 228.79,74.57 231.54,74.57 231.64,74.47 232.57,74.47 234.85,76.75 234.85,77.31 237.59,80.06 240.75,80.06 241.88,78.93 244.43,78.93 244.63,79.13 245.34,79.13 245.85,78.62 246.44,78.62 248.42,76.64 250.65,76.64 251.81,77.81 257.12,77.81 257.76,78.45 260.31,78.45 260.89,77.86 v2(261.58,77.86)
  IN3 w0.135: v2(135.88,120.47) 135.88,119.89 136.49,119.27 148.67,119.27 v2(149.12,119.72)
  BOTTOM w0.102: RC346.1 135.85,120.5 135.88,120.48 v2(135.88,120.47) ; 131.88,115.4 131.8,115.4 129.57,113.17 UC1.A6
  BOTTOM w0.112: v2(149.12,119.72) v1(149.93,120.53) 152.99,123.59 161.34,123.59 v2(161.48,123.44) ; 131.88,115.4 135.88,119.4 v2(135.88,120.47)
SIO_EXT_SMI#_EC: length 15.6
  TOP w0.107: UE1.K7 v2(254.28,88.26)
  TOP w0.112: v2(261.47,82.31) RE338.2 262.19,82.31 262.66,81.84 263.75,81.84 264.18,81.41 v1(264.18,81.16)
  IN2 w0.124: v2(254.28,88.26) 254.74,88.71 256.06,88.71 256.34,88.43 256.34,85.6 259.63,82.31 v2(261.47,82.31)
SIO_EXT_WAKE#: length 189
  TOP w0.107: v2(257.05,93.1) 256.13,93.1 255.69,92.66 UE1.M12
  IN2 w0.124: v2(257.05,93.1) 258.9,91.25 258.9,88.39 259.8,87.49 261.07,87.49 262.21,86.35 262.21,83.71 262.69,83.24 262.69,81.34 263.86,80.16 263.86,75.28 262.66,74.08 261.14,74.08 260.3,73.24 258.24,73.24 257.84,73.64 253.45,73.64 252.13,72.32 249.52,72.32 248.88,71.69 245.41,71.69 244.81,71.09 243.49,71.09 242.94,70.54 242.42,70.54 240.43,68.55 238.58,68.55 235.69,65.66 233.69,65.66 233.64,65.7 230.65,65.7 230.12,66.23 227.82,66.23 226.44,64.86 205.27,64.86 203.92,66.2 185.73,66.2 183.95,67.98 179.66,67.98 175.34,72.3 170.44,72.3 169.58,73.15 169.58,78.34 168.79,79.13 168.79,82.11 166.43,84.47 166.43,87.06 163.16,90.32 153.92,90.32 151.2,93.04 151.2,98.36 149.08,100.48 147.92,100.48 147.65,100.21 146.38,100.21 145.82,100.77 142.65,100.77 v2(142.57,100.85)
  BOTTOM w0.076: UC1.AC1 132.63,101.18 132.79,101.03 133.49,101.03 133.71,101.25
  BOTTOM w0.102: 133.71,101.25 134.09,101.63 135.58,101.63 135.74,101.47
  BOTTOM w0.112: 135.74,101.47 136.55,100.66 138.01,100.66 v1(138.2,100.85) 138.52,101.17 140.97,101.17 141.1,101.03 141.89,101.03 142.08,100.85 v2(142.57,100.85) 142.72,101 145.16,101 RC283.1
