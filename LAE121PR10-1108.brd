# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_N2_C: length 2.9
  TOP w0.076: 35.35,101.28 35.33,101.28 35.32,101.26 34.82,101.26 34.7,101.38 34.26,101.38 34.21,101.33 34.21,101.22 34.28,101.15 UT1.AC11
  TOP w0.104: CT15.2 36.24,100.98 36.1,100.98 35.79,101.28 35.35,101.28
CPU_DP1_N3: length 102.4
  TOP w0.104: CT17.1 39.29,101.94 39.57,101.94 39.83,102.2 39.83,102.63 40.33,103.13 v2(40.33,103.4)
  IN1 w0.076: 99.36,111.9 99.36,111.46 99.67,111.16 99.67,110.04 99.81,109.9 100.03,109.9 100.11,109.98 100.11,110.15 v2(100.04,110.23)
  IN1 w0.119: v2(40.33,103.4) 40.33,103.68 39.73,104.27 39.73,107.34 36.72,110.35 36.72,110.92 35.3,112.34 35.3,118.35 37.78,120.83 47.79,120.83 49.63,122.67 53.08,122.67 53.66,123.25 60.4,123.25 60.94,122.72 68.95,122.72 69.29,122.38 72.24,122.38 73.12,121.49 79.03,121.49 79.67,122.14 81.48,122.14 82.17,122.83 82.17,123.39 83.44,124.67 87.79,124.67 88.42,124.03 89.25,124.03 89.73,123.55 95.02,123.55 98.4,120.17 99.4,120.17 100.07,119.49 100.07,116.84 100.54,116.37 100.54,113.1 99.36,111.93 99.36,111.9
  BOTTOM w0.076: v2(100.04,110.23) 100.03,110.21 100.06,110.09 100.41,109.91 UC1.F56
CPU_DP1_N3_C: length 5
  TOP w0.076: UT1.AC13 34.28,102.07 34.21,102.14 34.21,102.25 34.26,102.3 34.7,102.3 34.82,102.18 35.32,102.18 35.33,102.2 35.35,102.2
  TOP w0.104: 35.35,102.2 35.79,102.2 36.08,101.9 38.31,101.9 CT17.2
CPU_DP1_P0: length 109.1
  TOP w0.104: v2(40.99,99) 40.79,99.2 37.57,99.2 CT10.1
  IN1 w0.076: v2(100.93,110.18) 100.83,110.18 100.39,110.62 100.39,111.16 100.43,111.2 100.43,111.26
  IN1 w0.119: 100.43,111.26 100.43,112.43 100.96,112.96 100.96,116.55 100.5,117.01 100.5,119.67 95.29,124.88 88.22,124.88 88,125.09 83.27,125.09 81.01,122.83 79.73,122.83 78.83,121.93 73.37,121.93 72.5,122.8 69.47,122.8 69.1,123.17 67.73,123.17 67.19,123.72 53.17,123.72 52.64,123.19 49.55,123.19 47.68,121.32 37.61,121.32 34.88,118.58 34.88,112.07 36.3,110.65 36.3,109.87 38.1,108.07 38.1,104.86 40.79,102.17 40.79,100.7 41.4,100.08 41.4,99.42 40.99,99 v2(40.99,99)
  BOTTOM w0.076: v2(100.93,110.18) 101.11,110.24 101.35,110.11 UC1.F55
CPU_DP1_P0_C: length 3.1
  TOP w0.076: UT1.AB7 34.12,99.15 34.19,99.15 34.25,99.1 34.69,99.1 34.82,99.23 35.35,99.23
  TOP w0.104: CT10.2 36.62,99.23 36.15,99.23 36.12,99.2 35.55,99.2 35.52,99.23 35.35,99.23
CPU_DP1_P1: length 92.7
  TOP w0.104: CT12.1 39.02,99.99 40.16,99.99 40.93,100.76 41.58,100.76 v2(41.77,100.57)
  IN1 w0.119: v2(99.12,110.18) 97.98,110.18 97.59,110.57 97.59,111.47 99.21,113.1 99.21,118.82 98.87,119.16 96.97,119.16 94.92,121.21 94.92,121.77 94,122.68 89.35,122.68 88.87,123.16 88.04,123.16 87.4,123.81 84.73,123.81 82.2,121.28 80.05,121.28 79.4,120.63 71.54,120.63 70.96,121.2 66.9,121.2 66.46,121.64 51.05,121.64 48.95,119.54 47.97,119.54 42.62,114.19 42.62,112.03 41.72,111.13 41.72,102.48 42.18,102.02 42.18,100.95 42.06,100.83 42.03,100.83 v2(41.77,100.57)
  BOTTOM w0.076: v2(99.12,110.18) UC1.F58
CPU_DP1_P1_C: length 4.5
  TOP w0.076: 35.35,100 35.33,100 35.32,100.01 34.18,100.01 UT1.AB9
  TOP w0.104: 35.35,100 36.34,100 36.35,100.01 38.1,100.01 CT12.2
CPU_DP1_P2: length 109.3
  TOP w0.104: v2(39.68,100.63) 39.51,100.8 37.22,100.8 CT14.1
  IN1 w0.076: v2(101.86,109.54) 101.74,109.54 101.33,109.95 101.33,111.22 101.63,111.51 101.63,111.84 101.61,111.87 101.61,111.9
  IN1 w0.119: v2(39.68,100.63) 39.94,100.89 39.95,100.89 40.11,101.05 40.11,101.79 38.05,103.85 37.26,103.85 36.4,104.71 36.4,105.78 35.61,106.56 35.61,110.42 34.23,111.8 34.23,118.9 38.05,122.72 48.09,122.72 49.34,123.97 52.46,123.97 52.86,124.37 67.92,124.37 68.4,123.89 73.2,123.89 73.87,123.21 78.83,123.21 79.09,123.47 80.74,123.47 83.41,126.14 90.54,126.14 90.92,125.75 94.17,125.75 94.38,125.96 95.11,125.96 101.14,119.94 101.14,117.28 101.61,116.81 101.61,111.9
  BOTTOM w0.076: UC1.G53 102.31,109.32 101.9,109.55 v2(101.86,109.54)
CPU_DP1_P2_C: length 2.8
  TOP w0.076: UT1.AB11 33.98,101.15 34.21,100.92 34.66,100.92 34.82,101.08 35.25,101.08 35.3,101.03 35.35,101.03
  TOP w0.104: CT14.2 36.25,100.78 36.01,100.78 35.76,101.03 35.35,101.03
CPU_DP1_P3: length 102.4
  TOP w0.104: v2(40.74,102.98) 40.47,102.98 40.03,102.54 40.03,102.11 39.66,101.74 39.31,101.74 CT16.1
  IN1 w0.076: 99.15,111.9 99.16,111.89 99.16,111.42 99.49,111.08 99.49,109.97 99.91,109.54 v2(100.04,109.54)
  IN1 w0.119: 99.15,111.9 99.15,112.02 100.32,113.19 100.32,116.28 99.85,116.75 99.85,119.4 99.31,119.95 98.31,119.95 94.93,123.33 89.64,123.33 89.16,123.81 88.33,123.81 87.7,124.45 83.53,124.45 82.38,123.3 82.38,122.74 81.57,121.92 79.76,121.92 79.12,121.27 73.03,121.27 72.15,122.16 69.2,122.16 68.86,122.5 60.85,122.5 60.31,123.03 53.76,123.03 53.17,122.45 49.72,122.45 47.89,120.61 37.87,120.61 35.52,118.26 35.52,112.43 36.94,111.01 36.94,110.45 39.95,107.43 39.95,104.36 40.85,103.46 40.85,103.1 v2(40.74,102.98)
  BOTTOM w0.076: v2(100.04,109.54) 100.2,109.59 100.45,109.46 UC1.G56
CPU_DP1_P3_C: length 5
  TOP w0.076: 35.35,101.99 35.33,101.99 35.32,102.01 34.82,102.01 34.65,101.84 34.21,101.84 33.98,102.07 UT1.AB13
  TOP w0.104: 35.35,101.99 35.7,101.99 36,101.7 37.35,101.7 37.38,101.67 37.95,101.67 37.98,101.7 38.38,101.7 CT16.2
CPU_DP2_AUXN: length 22.7
  IN1 w0.076: v2(104.61,110.81) 104.4,110.61 104.29,110.61 104.22,110.68 104.22,111.14 104.45,111.37 105.02,111.37 105.2,111.54 105.2,111.84 105.22,111.86 105.22,111.88
  IN1 w0.119: v2(106.37,123.56) 106.19,123.74 105.99,123.74 105.87,123.62 105.87,122.93 106.39,122.4 106.39,117.93 106.25,117.79 106.25,114.49 106.16,114.4 106.16,113.63 105.22,112.69 105.22,111.88
  BOTTOM w0.076: v2(104.61,110.81) UC1.E48
  BOTTOM w0.104: v2(106.37,123.56) 106.18,123.75 105.85,123.75 104.98,124.62 104.98,128.27 105.33,128.62 105.74,128.62 CV95.1
CPU_DP2_AUXN_C: length 2.8
  BOTTOM w0.104: CV95.2 106.69,128.59 107.14,128.59 v4(107.46,128.91) 107.98,129.43 108.25,129.43 108.36,129.54 UV7.25
CPU_DP2_AUXP: length 22.7
  IN1 w0.076: 105,111.88 105,111.86 105.02,111.84 105.02,111.61 104.95,111.54 104.37,111.54 104.04,111.21 104.04,110.61 104.22,110.43 104.35,110.43 v2(104.61,110.18)
  IN1 w0.119: 105,111.88 105,112.79 105.94,113.72 105.94,114.49 106.03,114.58 106.03,117.88 106.17,118.02 106.17,122.31 105.65,122.84 105.65,123.71 105.89,123.96 106.19,123.96 v2(106.37,124.14)
  BOTTOM w0.076: v2(104.61,110.18) UC1.F48
  BOTTOM w0.104: CV94.1 105.7,128.42 105.41,128.42 105.18,128.19 105.18,124.7 105.93,123.95 106.18,123.95 v2(106.37,124.14)
CPU_DP2_AUXP_C: length 2.8
  BOTTOM w0.104: UV7.24 108.35,129.14 108.26,129.23 108.06,129.23 107.86,129.03 107.86,128.99 107.38,128.51 107.34,128.51 107.22,128.39 106.66,128.39 CV94.2
CPU_DP2_CTRL_CLK: length 85.2
  TOP w0.076: v2(128.83,105.85) 128.75,105.92 128.75,106.05 128.9,106.2 129.65,106.2 129.67,106.18 129.69,106.18
  TOP w0.112: 129.69,106.18 131.09,106.18 131.32,106.41 134.36,106.41 136.74,108.79 143.54,108.79 148.36,113.61 148.69,113.61 RC176.1 149.31,113.62 149.76,113.62 150.21,114.07 150.21,117.34 146.28,121.27 146.28,122.56 144.47,124.37 135.29,124.37 131.07,128.59 131.07,130.48 129.33,132.22 124.12,132.22 121.92,130.02 116.25,130.02 115.56,129.32 114.06,129.32 111.22,126.48 108.05,126.48 107.52,127.01 107.52,127.13 v2(107.72,127.33)
  BOTTOM w0.102: v2(128.83,105.85) 128.87,105.85 129.04,106.01 UC1.N7
  BOTTOM w0.112: UV7.22 108.27,128.34 108.02,128.09 108.02,127.77 107.97,127.71 107.64,127.71 107.49,127.56 107.49,127.41 107.61,127.29 107.68,127.29 v2(107.72,127.33)
CPU_DP2_CTRL_DATA: length 85.4
  TOP w0.076: v2(128.24,105.83) 128.82,106.4 129.65,106.4 129.67,106.42 129.69,106.42
  TOP w0.112: 129.69,106.42 130.99,106.42 131.22,106.65 134.27,106.65 136.64,109.03 143.44,109.03 148.26,113.85 148.68,113.85 RC177.1 149.31,113.86 149.66,113.86 149.97,114.17 149.97,117.24 146.04,121.17 146.04,122.46 144.37,124.13 135.2,124.13 130.83,128.49 130.83,130.38 129.23,131.98 124.22,131.98 122.02,129.78 116.35,129.78 115.66,129.08 114.16,129.08 111.32,126.24 107.95,126.24 107.28,126.91 107.28,127.13 v2(107.09,127.33)
  BOTTOM w0.076: v2(128.24,105.83) 128.39,105.97 UC1.N8
  BOTTOM w0.112: UV7.23 108.33,128.74 107.09,127.5 v2(107.09,127.33)
CPU_DP2_HPD: length 38.4
  IN2 w0.124: v2(118.82,124.88) 119.95,124.88 120.92,123.92 128.71,123.92 129.03,123.6 131.86,123.6 132.32,123.13 132.32,122.23 131.85,121.75 131.85,118.82 132.47,118.21 132.47,116.81 132.21,116.55 129.85,116.55 128.83,115.54 128.83,107.29 v2(129.28,106.84)
  BOTTOM w0.102: v2(129.28,106.84) 129.04,107.09 UC1.L7
  BOTTOM w0.107: v2(118.82,124.88) 118.23,124.88 v1(117.09,126.02) 116.31,126.8 UV7.3
CPU_DP2_N0: length 26.5
  TOP w0.104: v2(115.37,123.82) 115.48,123.82 115.54,123.88 115.54,123.99 115.59,124.04 115.59,124.14 115.48,124.24 115.09,124.24 114.99,124.14 114.99,123.88 114.54,123.43 113.31,123.43 112.5,124.24 111.56,124.24 111.3,123.99 111.3,123.38 109.64,121.72 108.08,121.72 107.27,120.9 106.03,120.9 104.47,119.34 104.03,119.34 103.82,119.13 103.75,119.13 103.65,119.03 v2(103.65,118.96)
  BOTTOM w0.076: 104.42,114.07 104.41,114.06 104.41,114.05 104.38,114.01 104.38,114 104.27,113.9 104.27,113.78 104.28,113.78 arc(104.3,113.62) 104.36,113.48 arc(104.41,113.34) 104.39,113.2 arc(104.34,113) 104.38,112.79 arc(104.4,112.69) 104.39,112.59 arc(104.35,112.49) 104.29,112.41 arc(104.29,112.4) 104.29,112.4 104.25,112.37 104.09,112.37 104.02,112.29 104.02,112.18 103.99,112.15 103.99,112.09 104.07,112.01 UC1.C50
  BOTTOM w0.089: v2(103.65,118.96) 103.63,118.93 103.63,118.83 103.73,118.72 103.93,118.72 104.01,118.81 104.01,119.27 104.1,119.35 104.29,119.35 104.68,118.96 104.68,114.33 104.42,114.07
  BOTTOM w0.104: v2(115.37,123.82) 115.45,123.82 115.56,123.93 115.56,124.6 CV87.1
CPU_DP2_N0_C: length 2.3
  BOTTOM w0.104: UV7.7 114.71,126.86 114.81,126.75 114.81,126.45 115.52,125.73 115.52,125.58 CV87.2
CPU_DP2_N1: length 26.3
  TOP w0.104: v2(113.46,124.14) 113.46,124.14 113.56,124.04 113.76,124.04 113.89,124.17 113.89,124.42 113.46,124.85 109.4,124.85 108.99,124.44 108.99,123.55 108.44,123 107.58,123 106.76,122.17 105.47,122.17 104,120.71 103.29,120.71 102.44,119.86 102.44,119.38 101.78,118.72 101.78,116.37 101.98,116.17 102.23,116.17 102.42,116.35 v2(102.42,116.43)
  BOTTOM w0.076: UC1.C52 103.08,112.11 103.08,112.27 103.01,112.34 102.83,112.34 102.78,112.38 102.73,112.58 102.73,112.75 102.78,112.94 102.78,113.09 102.76,113.13 102.73,113.16 102.73,113.2 102.73,113.21 102.73,113.47 102.75,113.49 102.75,113.49 102.86,113.59 102.86,113.69 102.87,113.7
  BOTTOM w0.089: v2(102.42,116.43) 102.39,116.4 102.39,116.29 102.5,116.18 102.83,116.18 103.01,116 103.01,113.85 102.87,113.7
  BOTTOM w0.104: CV89.1 113.77,124.61 113.77,124.52 113.89,124.39 113.89,124.17 113.76,124.04 113.56,124.04 v2(113.46,124.14)
CPU_DP2_N1_C: length 2
  BOTTOM w0.104: UV7.10 113.51,126.87 113.62,126.77 113.62,125.91 113.77,125.76 113.77,125.6 CV89.2
CPU_DP2_N2: length 19.6
  TOP w0.104: v2(103.65,117.79) 103.65,117.74 103.99,117.4 104.37,117.4 104.88,117.91 104.88,118.98 106.37,120.47 107.47,120.47 108.3,121.31 109.99,121.31 111.99,123.31 111.99,123.59 111.92,123.65 111.92,123.75 111.85,123.82 v2(111.75,123.82)
  BOTTOM w0.076: UC1.A50 104.16,113.26 104.16,113.07 104.11,113.02 103.98,113.02 103.85,113.14 103.85,113.75 104.02,113.92 104.02,113.97 104.51,114.47 104.51,117.52 104.24,117.79 104.06,117.79
  BOTTOM w0.089: 104.06,117.79 v2(103.65,117.79)
  BOTTOM w0.104: CV91.1 111.94,124.6 111.94,124 111.76,123.82 v2(111.75,123.82)
CPU_DP2_N2_C: length 2.2
  BOTTOM w0.104: CV91.2 111.98,125.53 111.98,125.89 112.42,126.33 112.42,126.76 112.31,126.87 UV7.13
CPU_DP2_N3: length 19.9
  TOP w0.104: v2(103.63,115.37) 103.51,115.5 103.23,115.5 103.01,115.72 103.01,119.79 103.45,120.23 104.17,120.23 105.67,121.74 106.93,121.74 107.74,122.55 109.23,122.55 110.03,123.35 110.03,124.03 v2(109.98,124.08)
  BOTTOM w0.076: v2(103.63,115.37) 103.63,115.53 103.71,115.61 103.91,115.61 104,115.51 104,114.84 103.43,114.27 103.43,114.11 103.29,113.96 103.29,112.98 103.47,112.79 103.47,112.72 103.27,112.51 103.27,112.1 103.55,111.82 UC1.D51
  BOTTOM w0.104: CV93.1 110.19,124.57 110.19,124.28 v2(109.98,124.08)
CPU_DP2_N3_C: length 2.7
  BOTTOM w0.104: CV93.2 110.19,125.52 110.19,125.69 110.5,125.99 110.94,125.99 111.21,126.26 111.21,126.69 111.11,126.8 UV7.16
CPU_DP2_P0: length 26.5
  TOP w0.104: v2(103.65,119.54) 104.38,119.54 105.95,121.11 107.18,121.11 107.99,121.92 109.56,121.92 111.1,123.46 111.1,124.07 111.47,124.44 112.58,124.44 113.39,123.63 114.46,123.63 114.79,123.96 114.79,124.22 115.01,124.45 115.57,124.45 115.79,124.22 115.79,123.99 v2(115.95,123.82)
  BOTTOM w0.076: UC1.D50 104.11,111.62 104.49,112 104.49,112.35 104.49,112.35 104.49,112.35 arc(104.49,112.36) 104.49,112.36 104.49,112.36 104.49,112.39 arc(104.5,112.41) 104.51,112.43 arc(104.51,112.43) 104.51,112.43 arc(104.53,112.49) 104.55,112.56 arc(104.56,112.7) 104.53,112.85 arc(104.51,112.99) 104.54,113.14 arc(104.57,113.36) 104.5,113.57 arc(104.46,113.67) 104.45,113.78 104.45,113.83 104.55,113.94
  BOTTOM w0.089: 104.55,113.94 104.87,114.25 104.87,119.04 104.37,119.54 v2(103.65,119.54)
  BOTTOM w0.104: CV86.1 115.76,124.66 115.76,124.02 v2(115.95,123.82)
CPU_DP2_P0_C: length 2.3
  BOTTOM w0.104: CV86.2 115.72,125.59 115.72,125.82 115.01,126.53 115.01,126.78 115.11,126.88 UV7.6
CPU_DP2_P1: length 26.3
  TOP w0.104: v2(102.42,115.83) 102.28,115.97 101.9,115.97 101.58,116.29 101.58,118.8 102.24,119.46 102.24,119.94 103.21,120.91 103.92,120.91 105.38,122.38 106.67,122.38 107.5,123.2 108.36,123.2 108.79,123.63 108.79,124.52 109.32,125.05 113.54,125.05 114.09,124.5 114.09,124.35 v2(114.3,124.14)
  BOTTOM w0.076: 102.74,113.83 102.73,113.82 102.73,113.81 102.69,113.77 102.69,113.67 102.55,113.54 102.55,113.17 102.56,113.16 102.56,113.09 102.61,113.04 102.61,112.97 102.55,112.77 102.55,112.55 102.61,112.35 102.64,112.27 102.69,112.07 102.69,111.96 102.77,111.69 UC1.D52
  BOTTOM w0.089: v2(102.42,115.83) 102.42,115.86 102.55,116 102.75,116 102.83,115.92 102.83,113.92 102.74,113.83
  BOTTOM w0.104: v2(114.3,124.14) 114.09,124.35 114.09,124.47 113.99,124.58 113.99,124.67 CV88.1
CPU_DP2_P1_C: length 2
  BOTTOM w0.104: CV88.2 113.97,125.56 113.97,125.84 113.82,125.99 113.82,126.82 113.91,126.91 UV7.9
CPU_DP2_P2: length 19.6
  TOP w0.104: v2(103.65,117.2) 104.45,117.2 105.08,117.83 105.08,118.9 106.45,120.27 107.55,120.27 108.39,121.11 110.07,121.11 112.19,123.23 112.19,123.68 v2(112.33,123.82)
  BOTTOM w0.076: UC1.B50 104.08,112.66 103.67,113.07 103.67,113.82 103.85,113.99 103.85,114.05 104.34,114.54 104.34,117.45 104.18,117.61 103.98,117.61 103.65,117.28 v2(103.65,117.2)
  BOTTOM w0.104: CV90.1 112.14,124.54 112.14,124.49 112.14,124.48 112.14,124.02 v2(112.33,123.82)
CPU_DP2_P2_C: length 2.2
  BOTTOM w0.104: UV7.12 112.71,126.86 112.62,126.77 112.62,126.25 112.18,125.8 112.18,125.51 CV90.2
CPU_DP2_P3: length 19.9
  TOP w0.104: v2(110.56,124.08) 110.56,124.08 110.23,123.75 110.23,123.27 109.31,122.35 107.82,122.35 107.01,121.54 105.75,121.54 104.25,120.03 103.54,120.03 103.21,119.71 103.21,115.8 103.32,115.7 103.43,115.7 103.63,115.9 v2(103.63,116)
  BOTTOM w0.076: v2(103.63,116) 103.63,115.91 103.71,115.83 103.93,115.83 104.17,115.59 104.17,114.77 103.61,114.2 103.61,114.04 103.46,113.89 103.46,113.05 103.85,112.66 103.85,112.25 103.72,112.11 103.62,112.11 103.55,112.18 UC1.C51
  BOTTOM w0.104: v2(110.56,124.08) 110.39,124.26 110.39,124.56 CV92.1
CPU_DP2_P3_C: length 2.7
  BOTTOM w0.104: UV7.15 111.51,126.8 111.41,126.7 111.41,126.18 111.03,125.79 110.58,125.79 110.39,125.6 110.39,125.52 CV92.2
CPU_DP3_AUXN: length 1.1
  TOP w0.102: T1.1 105.58,109.57 v2(105.6,109.6)
  BOTTOM w0.102: UC1.G46 105.98,109.29 105.68,109.6 v2(105.6,109.6)
CPU_DP3_AUXP: length 1
  TOP w0.102: v2(105.58,110.23) 105.46,110.35 T2.1
  BOTTOM w0.102: UC1.F46 105.69,110.23 v2(105.58,110.23)
CPU_POPIRCOMP: length 11.9
  TOP w0.381: RC88.1 123.79,86.46 124.48,87.16 v1(124.48,88.07) v2(124.48,89.52)
  IN2 w0.254: 122.83,92.28 122.41,92.7 122.41,93.99 122.67,94.25 v2(122.86,94.25)
  IN2 w0.381: v2(124.48,89.52) 124.26,89.52 123.77,90 123.77,91.34 122.83,92.28
  BOTTOM w0.254: v2(122.86,94.25) 123,94.23 123.29,94.45 UC1.AT16
CPU_XDP_PRDY#: length 19.8
  TOP w0.112: v2(102.13,128.79) v1(102.13,125.87) 102.13,125.36 99.85,123.07 99.85,115.33 v2(99.9,115.28)
  BOTTOM w0.076: v2(99.9,115.28) 99.9,114.82 100.22,114.5 100.22,113.69 100.07,113.54 100.07,113.17 100.11,113.1 100.11,112.89 100.1,112.86 100.1,112.83 100.08,112.82 100.07,112.8 100.07,112.55 100.09,112.51 100.13,112.35 100.21,112.07 100.21,111.96 100.29,111.69 UC1.D56
  BOTTOM w0.112: JXDP1.5 102.31,128.97 v2(102.13,128.79)
CPU_XDP_PREQ#: length 23
  TOP w0.112: v2(98.1,114.93) 98.22,114.82 100.02,114.82 100.29,115.09 100.29,115.54 100.1,115.73 100.1,122.95 102.58,125.42 v1(102.58,127.95) 102.58,128.62 v2(102.74,128.79)
  BOTTOM w0.076: UC1.D61 98.3,111.63 98.3,111.81 98.32,111.83 98.32,112.2 98.3,112.22 98.3,112.46 98.32,112.48 98.32,114.71 v2(98.1,114.93)
  BOTTOM w0.112: RC138.1 102.74,128.13 v2(102.74,128.79) 102.91,128.96 JXDP1.3
CPU_XDP_TCLK: length 26.1
  IN1 w0.119: v2(96.59,118.25) 96.59,118.66 93.32,121.94 91.27,121.94 91.14,121.8 89.49,121.8 88.65,122.64 87.73,122.64 v2(87.45,122.93)
  BOTTOM w0.076: v2(96.59,118.25) 96.8,118.04 96.8,117.55 96.48,117.24 96.48,116.81 96.85,116.44 96.85,115.38 97.94,114.29 97.94,113.64 97.76,113.47 97.76,113.21 97.82,113.09 97.82,112.87 UC1.B61
  BOTTOM w0.112: v2(87.45,122.93) 87.45,124.71 87.12,125.03 87.12,127.6 RC139.1 86.46,128.26 86.46,129.11 86.71,129.37 JXDP1.57 ; RC328.1 v2(96.59,118.25)
CPU_XDP_TDI: length 28.6
  TOP w0.112: v3(80.39,120.95) 80.39,120.77 v2(80.1,120.48)
  IN1 w0.119: v2(80.1,120.48) 80.54,120.04 86.21,120.04 86.96,120.79 90.42,120.79 90.86,120.36 93.57,120.36 95.59,118.33 95.59,117.3 96.29,116.6 97.09,116.6 v2(97.41,116.91)
  BOTTOM w0.076: UC1.D60 98.59,111.93 98.88,112.22 98.88,112.46 98.67,112.68 98.67,115.11 97.76,116.01 97.76,116.56 v2(97.41,116.91)
  BOTTOM w0.112: UC8.6 80.3,120.75 80.1,120.54 v2(80.1,120.48) 80.03,120.48 79.78,120.23 RC134.1
CPU_XDP_TDO: length 23.8
  TOP w0.112: v3(82.23,119.91) 82.23,120.31 v2(82.09,120.45)
  IN1 w0.119: v2(82.09,120.45) 82.65,121.01 90.52,121.01 90.95,120.58 93.66,120.58 95.81,118.42 95.81,117.46 96.23,117.04 v2(96.84,117.04)
  BOTTOM w0.076: UC1.A61 98.11,113.4 98.11,114.37 97.05,115.43 97.05,116.83 v2(96.84,117.04)
  BOTTOM w0.112: UC8.3 81.8,120.8 82.09,120.52 v2(82.09,120.45) 82,120.37 RC135.1
CPU_XDP_TMS: length 30.8
  TOP w0.112: v3(96.88,115.63) 97.38,115.63 v2(97.43,115.69)
  IN1 w0.119: v2(79.51,117.55) 80.16,116.9 84.4,116.9 84.89,116.4 94.83,116.4 95.55,115.69 v2(97.43,115.69)
  BOTTOM w0.076: v2(97.43,115.69) 97.85,115.69 98.5,115.04 98.5,112.43 UC1.C60
  BOTTOM w0.112: UC8.8 78.61,122.8 RC131.1 77.88,122.07 77.88,121.36 78.87,120.36 78.87,118.25 79.51,117.61 v2(79.51,117.55)
CPU_XDP_TRST#: length 38.8
  TOP w0.112: CC308.1 96.8,120.93 96.8,119.58 97.41,118.97 v2(97.41,117.55) ; v2(84.96,123.3) v3(85.55,123.3)
  IN1 w0.119: v2(84.96,123.3) 86.13,122.14 88.45,122.14 89.35,121.23 90.61,121.23 91.05,120.8 93.75,120.8 96.03,118.51 96.03,117.93 v2(96.35,117.61) 97.34,117.61 v2(97.41,117.55)
  BOTTOM w0.076: UC1.C61 98.03,112.08 97.63,112.47 97.63,113.08 97.61,113.14 97.6,113.17 97.6,113.54 97.77,113.71 97.77,114.2 96.67,115.3 96.67,116.34 96.19,116.83 96.19,117.45 v2(96.35,117.61) ; v2(97.41,117.55) 97.93,117.03 97.93,116.08 98.83,115.18 98.83,112.99 UC1.B59
  BOTTOM w0.112: v2(84.96,123.3) 84.96,123.92 83.09,125.79 82.27,125.79 81.8,125.32 RC136.1 81.3,124.8 UC8.11
CSI2_COMP: length 10.7
  TOP w0.254: RC3.1 125.5,120.2 v1(125.5,119.56) v2(125.5,117.23)
  IN2 w0.254: v2(125.5,117.23) 125.37,117.1 125.37,111.5 v2(124.71,110.84)
  BOTTOM w0.254: UC1.E13 v2(124.71,110.84)
CSIN_ISL88738: length 6.8
  TOP w0.112: v2(55.88,60.36) 55.88,61.19 v1(55.74,61.33)
  TOP w0.203: PU901.14 55.92,60.28 55.88,60.32 v2(55.88,60.36)
  BOTTOM w0.254: PC927.1 56.53,59.71 v2(55.88,60.36) 55.88,61.38 55.38,61.87 PC925.2 54.41,61.87 PR910.2
CSIP_ISL88738: length 5.4
  TOP w0.112: v1(54.56,61.9) 55.27,61.19 v2(55.27,60.35)
  TOP w0.203: v2(55.27,60.35) 55.27,59.93 55.52,59.68 PU901.15
  BOTTOM w0.254: PC926.1 55.27,59.99 v2(55.27,60.35) PC925.1 54.41,60.96 PR909.2
CSON_ISL88738: length 5.4
  TOP w0.203: v2(59.84,54.87) 59.65,54.87 58.89,55.64 PU901.1
  BOTTOM w0.112: v1(60.74,54.01) 61.35,54.62 PR938.1
  BOTTOM w0.254: PC946.1 59.47,54.87 v2(59.84,54.87) 60.43,54.87 PC945.1 60.49,54.94 PR938.1
CSOP_ISL88738: length 5.1
  TOP w0.112: v1(60.34,54.68) 60.34,55.01 v2(59.84,55.51)
  TOP w0.203: v2(59.84,55.51) 59.52,55.51 59,56.04 PU901.2
  BOTTOM w0.254: PR937.1 60.49,55.83 PC945.2 60.36,55.84 60.03,55.51 v2(59.84,55.51) 59.79,55.51 PC942.1
CV2_ON: length 33.2
  TOP w0.112: RE539.2 245.22,79.72 v2(245.08,79.58) ; v1(234,58.75) 234,59.17 v2(233.17,59.99)
  IN3 w0.135: v2(245.08,79.58) 245.56,79.1 245.56,78.29 245.08,77.81 245.08,74.34 245.81,73.61 245.81,70.09 244,68.28 244,65.34 242.42,63.76 242.42,63.58 238.68,59.84 236.32,59.84 235.46,60.7 233.88,60.7 v2(233.17,59.99)
  BOTTOM w0.112: v2(233.17,59.99) 232.85,59.99 232.45,59.59 JUSH1.3
CV2_ON_R: length 31.5
  TOP w0.107: UE1.H8 v2(252.68,89.86)
  TOP w0.112: RE539.1 245.22,82.01 v2(245.63,82.42) ; v2(258.47,98.44) 258.68,98.65 RPE10.1
  IN2 w0.124: v2(258.47,98.44) 258.35,98.31 257.46,98.31 257.12,97.98 257.12,96.39 256.55,95.82 256.55,94.82 256.11,94.38 254.81,94.38 254.39,94.8 253.2,94.8 252.2,93.8 252.2,90.35 v2(252.68,89.86)
  IN3 w0.135: v2(245.63,82.42) 245.75,82.42 246.68,83.34 246.68,84.44 246.37,84.75 246.37,89.33 247.29,90.26 252.28,90.26 v2(252.68,89.86)
DAT_TP_SIO_I2C_CLK: length 78.5
  TOP w0.107: UE1.C12 247.86,93.08 247.86,93.67 247.65,93.89 247.65,94.37 v2(247.14,94.88)
  TOP w0.112: v2(229.04,60.03) 228.04,61.02 219.08,61.02 218,59.93 218,57.28 217.81,57.09 217.63,57.09 v2(217.42,57.3) 217.12,57.61 RZ347.1 ; RZ22.2 CZ80.1 211.52,55.28 v2(211.73,55.5)
  IN3 w0.135: v2(247.14,94.88) 246.96,95.06 245.85,95.06 244.25,93.47 244.25,91.54 241.47,88.75 241.47,85.96 241.69,85.74 243.1,85.74 243.39,85.46 243.39,81.41 243.81,80.99 243.81,73.84 244.2,73.45 244.2,70.87 241.26,67.93 241.26,65.91 240.49,65.14 240.49,64.62 240.09,64.21 237.53,64.21 235.98,62.67 230.93,62.67 228.88,60.62 228.88,60.18 v2(229.04,60.03)
  BOTTOM w0.112: v2(217.42,57.3) 217.3,57.18 214.86,57.18 214.27,56.59 212.83,56.59 v2(211.73,55.5)
DAT_TP_SIO_R: length 4.7
  TOP w0.112: RZ22.1 210.41,57.16 RZ18.2 210.55,58.63 v2(210.55,59.83) v1(209.74,60.64)
  BOTTOM w0.112: JKBTP1.8 v2(210.55,59.83)
DCIN1_EN: length 282.2
  TOP w0.112: v2(268.75,95.59) UE2.12
  IN2 w0.124: v2(43.78,60.58) 44.75,60.58 47.61,57.72 50.9,57.72 53.29,55.33 58.68,55.33 59.58,54.43 60.09,54.43 61.69,56.03 69.45,56.03 70.44,55.04 71.48,55.04 74.99,51.54 113.27,51.54 114.97,53.25 140.64,53.25 141.17,53.64 142.12,54.35 146.18,54.35 147.8,55.97 158.84,55.97 161.05,53.76 176.05,53.76 178.51,51.29 179.22,51.29 179.56,51.63 182.96,51.63 184.26,50.33 209.12,50.33 210.63,51.84 213.3,51.84 213.85,51.29 225.68,51.29 226.32,51.93 228.51,51.93 228.93,51.51 237.92,51.51 239.94,53.53 239.94,54.32 242.37,56.74 243.1,56.74 245.54,59.19 245.54,60.03 249.68,64.17 252.02,64.17 253.06,65.21 256.16,65.21 256.46,65.52 260.98,65.52 263.23,67.76 268.96,67.76 270.82,69.62 270.82,76.77 267.53,80.06 267.53,83.42 266.49,84.47 266.49,87.24 271.85,92.6 271.85,93.75 271.44,94.15 270.19,94.15 v2(268.75,95.59)
  BOTTOM w0.112: v2(43.78,60.58) v1(43.78,61.39)
  BOTTOM w0.254: PR1221.1 41.88,60.91 42.76,60.91 43.09,60.58 v2(43.78,60.58)
DCIN2_EN: length 336.9
  TOP w0.112: UE2.15 v2(267.25,95.58) ; v2(60.15,118.17) v1(60.15,117.65)
  TOP w0.254: PR26.1 v2(60.15,118.17)
  IN2 w0.124: v2(60.15,118.17) 60.15,115.57 60.1,115.52 60.1,113.14 62.28,110.96 70.08,110.96 70.26,110.78 70.26,104.71 71.32,103.64 72.34,103.64 72.85,103.13 72.85,89.19 72.49,88.83 72.49,85.28 61.97,74.76 61.97,67.4 64.06,65.31 64.06,59.93 62.6,58.47 62.6,56.9 63.25,56.25 69.55,56.25 70.53,55.27 72.53,55.27 76.04,51.77 102.55,51.77 104.3,53.52 140.55,53.52 142.02,54.62 146.12,54.62 147.7,56.2 158.94,56.2 161.15,53.99 176.15,53.99 178.61,51.52 179.12,51.52 179.48,51.88 183.06,51.88 184.38,50.56 209,50.56 210.5,52.07 213.39,52.07 213.92,51.54 225.61,51.54 226.22,52.15 229.26,52.15 229.67,51.74 237.83,51.74 239.72,53.63 239.72,54.41 242.27,56.97 243,56.97 245.31,59.28 245.31,60.13 249.6,64.43 251.92,64.43 252.93,65.44 256.01,65.44 256.31,65.75 260.88,65.75 263.12,67.99 268.87,67.99 270.6,69.72 270.6,76.67 267.3,79.97 267.3,83.34 266.24,84.4 266.24,87.31 271.62,92.69 271.62,93.46 271.19,93.9 269.79,93.9 268.68,95.01 267.82,95.01 v2(267.25,95.58)
DCIN3_EN: length 4.2
  TOP w0.107: UE1.F12 250.28,93.06 250.28,94.99 249.96,95.31 T262.1
DCIN_ISL88738: length 3.6
  BOTTOM w0.112: v1(52.58,60.82) 53.26,60.13 PR916.1
  BOTTOM w0.508: PR916.1 53.52,59.7 PC931.2 v2(54.44,59)
DDR_A_ACT#: length 44.4
  IN3 w0.076: v2(98.59,84.15) 98.41,84.15 97.71,83.44 97.71,81.21 95.94,79.45 95.94,77.35
  IN3 w0.183: 95.94,77.35 95.94,68.42 96.63,67.73 96.63,67.08 99.31,64.4 99.31,60.98 100.24,60.05 100.24,57.95 100.7,57.49 101.68,57.49 v2(101.91,57.26)
  BOTTOM w0.076: v2(98.59,84.15) 99.25,84.81 v1(99.25,86.88) 99.25,87.35 100.81,88.9 100.81,89.86 100.79,89.88 100.79,90.27 100.93,90.41 100.93,90.82 100.88,90.96 100.88,91.07 100.93,91.2 100.93,91.43 UC1.BA55
  BOTTOM w0.183: JDIMM1.114 104.48,54.74 101.96,57.26 v2(101.91,57.26)
DDR_A_ALERT#: length 53
  IN3 w0.076: v2(104.56,92.42) 104.21,92.78 104.21,94.12 103.92,94.41 100.79,94.41 100.49,94.11 100.49,84.1 99.08,82.69 99.08,81.59 98.65,81.16
  IN3 w0.183: v2(104.79,55.35) 104.31,54.87 102.9,54.87 102.72,55.06 102.72,60.86 101.58,62 101.58,64.39 98.04,67.92 98.04,68.31 97.33,69.02 97.33,79.85 98.65,81.16
  BOTTOM w0.076: v2(104.56,92.42) 104.35,92.64 UC1.AW50
  BOTTOM w0.183: v2(104.79,55.35) 104.79,55.04 104.98,54.86 JDIMM1.116
DDR_A_BA0: length 45.6
  IN3 w0.076: v2(102.78,93.46) 102.78,92.91 104.11,91.58 104.11,89.76 106.15,87.73 106.15,80.06 106.54,79.66
  IN3 w0.183: v2(113.97,56.75) 113.96,56.75 113.06,57.65 113.06,59.3 113.1,59.35 113.1,64.93 107.11,70.93 107.11,79.1 106.54,79.66
  BOTTOM w0.076: v2(102.78,93.46) 102.78,93.47 UC1.AU52
  BOTTOM w0.183: v2(113.97,56.75) 115.48,55.25 JDIMM1.150
DDR_A_BA1: length 45.8
  IN3 w0.076: 108.96,78.73 108.96,78.93 107.16,80.72 107.16,90.92 104.98,93.1 104.98,94.04 104.91,94.1 v2(104.61,94.1)
  IN3 w0.183: v2(115.6,58.66) 115.6,58.97 114.95,59.62 114.95,65.74 108.96,71.74 108.96,78.73
  BOTTOM w0.076: v2(104.61,94.1) UC1.AT48
  BOTTOM w0.183: JDIMM1.145 114.23,61.9 114.23,59.84 114.42,59.64 114.42,58.4 114.6,58.22 115.16,58.22 v2(115.6,58.66)
DDR_A_BG0: length 46.7
  IN3 w0.076: v2(98.6,83.57) 98.6,83.7 98.52,83.78 98.28,83.78 97.87,83.38 97.87,81.14 96.41,79.67 96.41,77.35
  IN3 w0.183: 96.41,77.35 96.41,68.62 97.1,67.93 97.1,67.27 99.78,64.59 99.78,61.17 100.7,60.24 100.7,58.14 100.89,57.96 101.34,57.96 101.52,58.14 101.52,58.42 101.63,58.53 v2(101.91,58.53)
  BOTTOM w0.076: v2(98.6,83.57) 98.6,83.44 98.84,83.2 99.16,83.2 99.24,83.28 99.24,84.14 99.58,84.48 99.58,87.43 101.53,89.39 101.53,90.19 101.39,90.33 101.39,90.83 101.41,90.86 101.44,90.94 101.44,91.06 101.37,91.28 101.37,91.42 101.43,91.58 101.43,91.76 101.4,91.83 101.27,91.96 101.08,91.96 100.99,92.05 100.99,92.24 UC1.AY55
  BOTTOM w0.183: JDIMM1.115 104.73,61 103.99,60.26 103.99,59.72 103.41,59.14 102.52,59.14 v2(101.91,58.53)
DDR_A_BG1: length 47.3
  IN3 w0.076: 96.87,77.35 96.87,79.81 98.07,81.02 98.07,82.19 98.17,82.28 98.58,82.28 v2(98.6,82.27)
  IN3 w0.183: v2(101.91,59.8) 101.91,59.79 101.65,59.53 101.35,59.53 101.17,59.71 101.17,60.24 101.79,60.87 101.79,61.13 101.56,61.36 101.3,61.36 100.93,61 100.67,61 100.24,61.43 100.24,61.71 100.42,61.89 100.93,61.89 101.12,62.08 101.12,62.44 100.93,62.62 100.42,62.62 100.24,62.81 100.24,63.17 100.42,63.36 100.93,63.36 101.12,63.54 101.12,63.9 100.93,64.09 100.42,64.09 100.24,64.27 100.24,64.78 99.46,65.56 99.46,65.85 99.09,66.22 98.8,66.22 98.42,66.59 98.42,66.89 98.05,67.26 97.76,67.26 97.56,67.46 97.56,68.12 96.87,68.81 96.87,77.35
  BOTTOM w0.076: v2(98.6,82.27) 99.04,82.27 99.4,82.62 99.4,83.82 99.79,84.21 99.79,87.4 101.7,89.31 101.7,90.31 101.56,90.45 101.56,90.79 101.61,90.91 101.61,91.05 101.55,91.28 101.55,91.41 101.62,91.63 101.62,91.89 UC1.AY54
  BOTTOM w0.183: v2(101.91,59.8) 101.91,60.19 102.09,60.37 102.61,60.37 102.74,60.23 102.74,59.81 102.92,59.62 103.28,59.62 103.55,59.9 103.55,60.52 104.23,61.19 JDIMM1.113
DDR_A_CKE0: length 45.9
  IN3 w0.076: v2(98.6,85.98) 98.39,85.98 97.27,84.86 97.27,81.26 95.48,79.47 95.48,77.35
  IN3 w0.183: 95.48,77.35 95.48,68.23 96.17,67.54 96.17,66.89 98.85,64.21 98.85,60.49 98.3,59.94 98.3,57.75 98.48,57.57 99.16,57.57 99.35,57.75 99.35,58.95 99.63,59.23 v2(99.79,59.23)
  BOTTOM w0.076: v2(98.6,85.98) 98.28,85.98 98.21,86.05 98.21,87.04 100.31,89.13 100.31,89.69 100.29,89.7 100.29,90.42 100.23,90.49 100.23,90.79 100.23,90.79 100.35,91.04 100.35,91.04 100.36,91.05 100.5,91.19 UC1.BA56
  BOTTOM w0.183: v2(99.79,59.23) 99.79,59.23 101.37,60.81 102.95,60.81 103.23,61.08 JDIMM1.109
DDR_A_CKE1: length 45
  IN3 w0.076: v2(98.59,86.62) 97.11,85.14 97.11,81.42 95.02,79.33 95.02,77.35
  IN3 w0.183: 95.02,77.35 95.02,68.04 95.71,67.35 95.71,66.69 98.39,64.02 98.39,61.57 97.78,60.96 97.78,57.33 99.11,55.99 v2(101.91,55.99)
  BOTTOM w0.076: v2(98.59,86.62) 98.59,87.17 100.48,89.05 100.48,89.75 100.46,89.76 100.46,90.65 UC1.BB56
  BOTTOM w0.183: v2(101.91,55.99) 102.08,55.99 103.48,54.6 JDIMM1.110
DDR_A_CKE2: length 9.7
  TOP w0.107: v2(98.58,84.75) 98,84.75 T3.1
  BOTTOM w0.076: v2(98.58,84.75) 98.97,85.14 98.97,87.31 100.64,88.98 100.64,89.8 100.62,89.82 100.62,90.35 100.76,90.49 100.76,90.79 100.71,90.9 100.71,91.12 100.76,91.23 100.76,91.44 100.73,91.52 100.73,91.8 100.74,91.8 100.76,91.86 100.76,92.17 100.71,92.22 100.71,92.42 UC1.AW56
DDR_A_CKE3: length 7.3
  BOTTOM w0.076: UC1.AY56 100.5,91.78 100.23,91.52 100.23,91.23 100.09,90.87 100.08,90.86 100.07,90.82 100.07,89.68 100.13,89.62 100.13,89.19 97.89,86.95 97.89,85.84 T4.1
DDR_A_CLK0: length 46.8
  IN3 w0.076: v2(101.86,94.04) 101.84,94.06 101.59,94.06 101.48,93.94 101.48,91.52 101.66,91.34 102.72,91.34 102.81,91.24 102.81,89.94 105.05,87.7 105.05,87.67
  IN3 w0.117: 105.05,87.67 105.19,87.53 105.19,79.51 105.76,78.94 105.76,70.38 111.45,64.69 111.45,59.12 111.69,58.88 112.28,58.88 v2(112.31,58.85)
  BOTTOM w0.076: v2(101.86,94.04) 101.86,94.28 102.04,94.45 UC1.AT53
  BOTTOM w0.104: v2(112.31,58.85) 110.65,58.85 110.19,59.31 110.19,60.42 110.39,60.62 110.39,60.89 110.23,61.06 JDIMM1.137
DDR_A_CLK1: length 47.2
  IN3 w0.076: v2(100.95,94.04) 101.31,93.69 101.31,93.12 101.31,93.11 101.31,91.42 102.09,90.64 102.09,89.99 104.31,87.77 104.34,87.77 104.34,87.77
  IN3 w0.117: 104.34,87.77 104.72,87.39 104.72,78.89 105.13,78.48 105.13,70.12 110.83,64.42 110.83,58.5 111.81,57.52 112.25,57.52 v2(112.31,57.58)
  BOTTOM w0.076: v2(100.95,94.04) 100.95,94.1 UC1.AT55
  BOTTOM w0.104: v2(112.31,57.58) 112.2,57.47 111.53,57.47 111.02,56.97 111.02,56.17 110.64,55.78 110.64,54.65 110.48,54.48 JDIMM1.138
DDR_A_CLK#0: length 46.9
  IN3 w0.076: v2(101.86,93.46) 101.89,93.48 102.12,93.48 102.23,93.38 102.23,93.2 102.13,93.09 101.74,93.09 101.65,93 101.65,91.59 101.73,91.51 102.79,91.51 102.98,91.31 102.98,90.02 105.18,87.82 105.2,87.82
  IN3 w0.117: 105.2,87.82 105.4,87.62 105.4,79.6 105.97,79.03 105.97,70.47 111.66,64.78 111.66,59.21 111.78,59.09 111.97,59.09 112.31,59.43 v2(112.31,59.53)
  BOTTOM w0.076: UC1.AU53 102.42,93.7 102.42,93.44 102.26,93.28 102.02,93.28 101.86,93.43 v2(101.86,93.46)
  BOTTOM w0.104: v2(112.31,59.53) 112.31,59.42 111.94,59.05 110.74,59.05 110.39,59.4 110.39,60.34 110.59,60.54 110.59,60.92 110.73,61.05 JDIMM1.139
DDR_A_CLK#1: length 47.2
  IN3 w0.076: v2(100.95,93.46) 100.94,93.47 100.85,93.47 100.79,93.41 100.79,93.18 100.87,93.1 101.08,93.1 101.14,93.04 101.14,91.35 101.92,90.57 101.92,89.92 104.19,87.65 104.19,87.62
  IN3 w0.117: 104.19,87.62 104.51,87.3 104.51,78.8 104.92,78.4 104.92,70.03 110.62,64.33 110.62,58.41 111.72,57.31 111.99,57.31 112.31,56.99 v2(112.31,56.94)
  BOTTOM w0.076: UC1.AU55 101.23,93.8 100.95,93.6 v2(100.95,93.46)
  BOTTOM w0.104: JDIMM1.140 110.98,54.52 110.84,54.65 110.84,55.7 111.23,56.08 111.23,56.88 111.61,57.27 112.05,57.27 112.31,57 v2(112.31,56.94)
DDR_A_CS#0: length 50.3
  IN3 w0.076: v2(106.44,93.47) 106.44,94.02 106.36,94.09 105.99,94.09 105.88,93.98 105.88,93.09 107.83,91.13 107.83,81.4 110.34,78.9 110.34,78.55
  IN3 w0.183: 110.34,78.55 110.34,72.31 116.82,65.83 116.82,65.55 116.64,65.37 116.52,65.37 116.34,65.18 116.34,64.82 116.52,64.64 116.64,64.64 116.82,64.45 116.82,62.95 116.64,62.77 116.52,62.77 116.34,62.58 116.34,62.22 116.52,62.03 116.64,62.03 116.82,61.85 116.82,61.41 117.35,60.89 117.35,59.15 117.67,58.83 117.67,57.98 117.48,57.79 117.15,57.79 v2(116.94,58)
  BOTTOM w0.076: UC1.AU45 106.89,93.89 106.71,94.07 106.45,94.07 106.26,93.89 106.26,93.53 106.32,93.47 v2(106.44,93.47)
  BOTTOM w0.183: JDIMM1.149 115.23,61.9 115.23,61.02 115.02,60.82 115.02,59.88 116.9,58 v2(116.94,58)
DDR_A_CS#1: length 52
  IN3 w0.076: 111.27,78.27 111.27,78.67 108.94,81 108.94,91.65 107.35,93.24 v2(107.35,93.46)
  IN3 w0.183: v2(118.11,57.77) 117.71,57.37 117.71,55.95 117.9,55.76 118.92,55.76 119.15,55.99 119.15,57.95 118.59,58.52 118.59,59.72 119.29,60.42 119.29,62.94 117.75,64.48 117.75,66.22 111.27,72.7 111.27,78.27
  BOTTOM w0.102: UC1.AU43 v2(107.35,93.46)
  BOTTOM w0.183: JDIMM1.157 117.23,61.9 117.23,61.02 118.57,59.68 118.57,58.22 v2(118.11,57.77)
DDR_A_D0: length 61.6
  IN3 w0.117: v2(77.23,57.47) 76.82,57.88 76.82,59.28 75.63,60.47 75.63,66.15 76.83,67.35 76.83,83.8 76.95,83.91 77.17,83.91 77.29,84.03 77.29,84.27 77.17,84.38 76.95,84.38 76.83,84.5 76.83,84.73 76.95,84.85 77.17,84.85 77.29,84.97 77.29,85.2 77.17,85.32 76.95,85.32 76.83,85.43 76.83,86.41 76.95,86.52 77.17,86.52 77.29,86.64 77.29,86.87 77.17,86.99 76.95,86.99 76.83,87.11 76.83,87.42 76.95,87.53 77.17,87.53 77.29,87.65 77.29,87.88 77.17,88 76.95,88 76.83,88.12 76.83,93.29 81.02,97.48 87.51,97.48 v2(88.42,96.58)
  BOTTOM w0.076: 89.14,97.14 90.14,97.14 90.49,97.49 91.76,97.49 UC1.AL71
  BOTTOM w0.102: v2(88.42,96.58) 88.98,97.14 89.14,97.14
  BOTTOM w0.112: v2(77.23,57.47) 77.66,57.9 77.66,60.86 77.73,60.92 JDIMM1.7
DDR_A_D1: length 62.4
  IN3 w0.117: v2(77.23,54.93) 77.23,54.23 77.35,54.11 78,54.11 78.12,54.23 78.12,59.4 77.41,60.11 77.41,62.67 77.29,62.78 76.74,62.78 76.63,62.9 76.63,63.37 77.83,64.57 77.83,76.35 78.29,76.81 78.29,93.28 81.32,96.32 83.49,96.32 83.82,95.99 v2(83.82,95.57)
  BOTTOM w0.076: 84.24,95.32 86.85,95.32 87.24,95.71 88.71,95.71 89.44,96.43 91.23,96.43 91.41,96.61 91.93,96.61 91.96,96.6 92.04,96.57 92.16,96.57 92.38,96.63 92.52,96.63 92.68,96.58 92.86,96.58 93.04,96.67 93.53,96.67 93.69,96.83 93.69,97.46 UC1.AL68
  BOTTOM w0.089: 84.07,95.32 v2(83.82,95.57)
  BOTTOM w0.112: JDIMM1.4 76.98,54.67 v2(77.23,54.93) ; 84.24,95.32 84.07,95.32
DDR_A_D2: length 63.4
  IN3 w0.117: v2(88.11,94.77) 88.11,94.96 87.86,95.21 86.89,95.21 85.23,93.55 85.23,92.56 85.23,92.55 85.23,90.36 84.9,90.03 84.9,89.82 80.95,85.86 79.95,85.86 79.76,85.66 79.76,75.97 79.64,75.86 79.41,75.86 79.3,75.74 79.3,75.51 79.41,75.39 79.64,75.39 79.76,75.27 79.76,75.04 79.64,74.92 79.41,74.92 79.3,74.8 79.3,74.57 79.41,74.45 79.64,74.45 79.76,74.34 79.76,74.1 79.64,73.99 79.41,73.99 79.3,73.87 79.3,73.64 79.41,73.52 79.64,73.52 79.76,73.4 79.76,73.17 79.64,73.05 79.41,73.05 79.3,72.94 79.3,72.7 79.41,72.58 79.64,72.58 79.76,72.47 79.76,72.23 79.64,72.12 79.41,72.12 79.3,72 79.3,71.77 79.41,71.65 79.64,71.65 79.76,71.53 79.76,71.3 79.64,71.18 79.41,71.18 79.3,71.07 79.3,70.83 79.41,70.72 79.64,70.72 79.76,70.6 79.76,70.36 79.64,70.25 79.41,70.25 79.3,70.13 79.3,69.91 79.41,69.8 79.64,69.8 79.76,69.68 79.76,69.45 79.64,69.33 79.41,69.33 79.3,69.21 79.3,68.98 79.41,68.86 79.64,68.86 79.76,68.74 79.76,68.51 79.64,68.39 79.41,68.39 79.3,68.28 79.3,68.04 79.41,67.93 79.64,67.93 79.76,67.81 79.76,67.58 79.64,67.46 79.41,67.46 79.3,67.34 79.3,67.11 79.41,66.99 79.64,66.99 79.76,66.87 79.76,66.64 79.64,66.52 79.41,66.52 79.3,66.41 79.3,66.17 79.41,66.06 79.64,66.06 79.76,65.94 79.76,65.71 79.64,65.59 79.41,65.59 79.3,65.47 79.3,65.24 79.41,65.12 79.64,65.12 79.76,65.01 79.76,64.77 79.64,64.65 79.41,64.65 79.3,64.54 79.3,64.3 79.41,64.19 79.64,64.19 79.76,64.07 79.76,63.84 79.64,63.72 79.35,63.72 79.24,63.6 79.24,63.37 79.35,63.25 79.64,63.25 79.76,63.14 79.76,62.9 79.64,62.79 79.29,62.79 79.17,62.67 79.17,62.38 79.29,62.26 79.68,62.26 79.79,62.15 79.79,59.59 80.06,59.32 v2(80.06,58.74)
  BOTTOM w0.076: v2(88.11,94.77) 88.24,94.91 88.98,94.91 89.83,95.75 91.49,95.75 91.49,95.75 92.43,95.75 92.63,95.96 92.8,96.01 92.91,95.99 93.01,95.96 93.09,95.93 93.19,95.93 93.39,96.14 93.39,96.36 93.49,96.46 93.64,96.46 93.74,96.36 UC1.AN68
  BOTTOM w0.112: v2(80.06,58.74) 80.06,59.13 80.17,59.24 80.43,59.24 80.54,59.35 80.54,59.58 80.43,59.69 80.17,59.69 80.06,59.8 80.06,60.01 80.17,60.13 80.43,60.13 80.54,60.24 80.54,60.42 80.43,60.53 79.96,60.53 79.84,60.64 79.84,60.82 79.96,60.93 80.14,60.93 80.23,61.02 JDIMM1.17
DDR_A_D3: length 62.5
  IN3 w0.117: v2(86.35,93.05) 86.23,92.93 86.23,89.94 85.9,89.61 85.9,89.4 81.21,84.71 81.21,74.17 81.09,74.05 80.87,74.05 80.76,73.93 80.76,73.7 80.87,73.58 81.09,73.58 81.21,73.46 81.21,73.23 81.09,73.11 80.87,73.11 80.76,73 80.76,72.76 80.87,72.65 81.09,72.65 81.21,72.53 81.21,72.3 81.09,72.18 80.87,72.18 80.76,72.06 80.76,71.83 80.87,71.71 81.09,71.71 81.21,71.59 81.21,71.36 81.09,71.24 80.87,71.24 80.76,71.13 80.76,70.89 80.87,70.78 81.09,70.78 81.21,70.66 81.21,70.43 81.09,70.31 80.87,70.31 80.76,70.19 80.76,69.96 80.87,69.84 81.09,69.84 81.21,69.73 81.21,69.49 81.09,69.37 80.87,69.37 80.76,69.26 80.76,69.02 80.87,68.91 81.09,68.91 81.21,68.79 81.21,68.56 81.09,68.44 80.87,68.44 80.76,68.32 80.76,68.09 80.87,67.97 81.09,67.97 81.21,67.86 81.21,67.62 81.09,67.51 80.87,67.51 80.76,67.39 80.76,67.15 80.87,67.04 81.09,67.04 81.21,66.92 81.21,66.7 80.76,66.25 80.76,64.35 81.43,63.67 81.43,57.72 81.84,57.31 81.84,55.55 82.37,55.03 82.37,53.86 82.14,53.63 79.58,53.63 79.37,53.84 79.37,54.77 79.53,54.93 v2(80.06,54.93)
  BOTTOM w0.076: UC1.AN69 92.98,96.38 92.73,96.38 92.51,96.46 92.38,96.46 92.15,96.39 92.05,96.39 92.04,96.39 92.03,96.39 92.01,96.39 91.89,96.45 91.49,96.45 91.29,96.24 89.5,96.24 88.79,95.53 87.44,95.53
  BOTTOM w0.102: v2(86.35,93.05) 86.26,93.14 86.26,94.35 87.44,95.53
  BOTTOM w0.112: v2(80.06,54.93) 79.98,54.84 JDIMM1.16
DDR_A_D4: length 62.6
  IN3 w0.117: v2(77.23,58.74) 77.23,59.34 75.96,60.61 75.96,66.01 76.27,66.32 76.95,66.32 77.16,66.53 77.16,77.44 77.28,77.56 77.5,77.56 77.62,77.67 77.62,77.91 77.5,78.02 77.28,78.02 77.16,78.14 77.16,78.37 77.28,78.49 77.5,78.49 77.62,78.61 77.62,78.84 77.5,78.96 77.28,78.96 77.16,79.07 77.16,79.31 77.28,79.43 77.5,79.43 77.62,79.54 77.62,79.78 77.5,79.89 77.28,79.89 77.16,80.01 77.16,80.24 77.28,80.36 77.5,80.36 77.62,80.48 77.62,80.71 77.5,80.83 77.28,80.83 77.16,80.94 77.16,81.18 77.28,81.29 77.5,81.29 77.62,81.41 77.62,81.64 77.5,81.76 77.28,81.76 77.16,81.88 77.16,82.11 77.28,82.23 77.5,82.23 77.62,82.35 77.62,82.56 77.5,82.68 77.28,82.68 77.16,82.8 77.16,83.03 77.28,83.15 77.5,83.15 77.62,83.27 77.62,93.57 81.15,97.1 86.63,97.1 v2(87.15,96.58)
  BOTTOM w0.076: 88.47,97.01 88.78,97.33 90.07,97.33 90.4,97.65 91.51,97.65 91.63,97.78 91.87,97.78 91.99,97.74 92.11,97.68 92.29,97.51 UC1.AL70
  BOTTOM w0.102: v2(87.15,96.58) 87.58,97.01 88.47,97.01
  BOTTOM w0.112: v2(77.23,58.74) 77.3,58.81 77.3,59.55 77.2,59.65 76.59,59.65 76.48,59.77 76.48,60.15 76.59,60.26 77.2,60.26 77.3,60.36 77.3,60.72 77.2,60.82 76.83,60.82 76.73,60.92 JDIMM1.3
DDR_A_D5: length 63.4
  IN3 w0.117: v2(77.23,56.2) 77.42,56.01 77.67,56.01 77.78,56.13 77.78,59.26 77.07,59.97 77.07,60.5 76.95,60.63 76.41,60.63 76.29,60.75 76.29,61.75 76.41,61.87 76.79,61.87 76.91,61.98 76.91,62.22 76.79,62.33 76.41,62.33 76.29,62.45 76.29,63.51 77.05,64.27 77.05,64.49 76.94,64.6 76.41,64.6 76.29,64.72 76.29,64.95 76.41,65.07 76.94,65.07 77.05,65.19 77.05,65.41 76.94,65.52 76.41,65.52 76.29,65.64 76.29,65.87 76.41,65.99 77.38,65.99 77.49,66.11 77.49,76.49 77.95,76.95 77.95,93.42 81.27,96.73 86.36,96.73 v2(86.51,96.58)
  BOTTOM w0.076: UC1.AL69 92.88,97.51 92.62,97.78 92.45,97.78 92.26,97.85 92.26,97.85 92.13,97.89 92.05,97.9 91.98,97.91 91.92,97.93 91.85,97.95 91.55,97.95 91.41,97.82 90.33,97.82 90,97.49 88.64,97.49 88.39,97.24 87.17,97.24
  BOTTOM w0.102: 87.17,97.24 v2(86.51,96.58)
  BOTTOM w0.112: v2(77.23,56.2) 77.98,55.46 JDIMM1.8
DDR_A_D6: length 61.1
  IN3 w0.117: v2(80.06,57.47) 80.3,57.24 80.65,57.24 80.77,57.35 80.77,58.57 80.65,58.69 80.59,58.69 80.48,58.81 80.48,59.04 80.59,59.16 80.65,59.16 80.77,59.27 80.77,59.49 80.65,59.61 80.24,59.61 80.13,59.73 80.13,59.96 80.26,60.09 80.65,60.09 80.77,60.21 80.77,60.44 80.65,60.56 80.24,60.56 80.13,60.68 80.13,60.91 80.24,61.03 80.65,61.03 80.77,61.14 80.77,61.38 80.65,61.49 80.24,61.49 80.13,61.61 80.13,61.83 80.24,61.95 80.65,61.95 80.77,62.06 80.77,62.3 80.65,62.41 80.24,62.41 80.09,62.57 80.09,78.86 80.21,78.98 80.43,78.98 80.55,79.09 80.55,79.33 80.43,79.44 80.21,79.44 80.09,79.56 80.09,79.79 80.21,79.91 80.43,79.91 80.55,80.03 80.55,80.26 80.43,80.38 80.21,80.38 80.09,80.49 80.09,80.73 80.21,80.84 80.43,80.84 80.55,80.96 80.55,81.2 80.43,81.31 80.21,81.31 80.09,81.43 80.09,81.66 80.21,81.78 80.43,81.78 80.55,81.9 80.55,82.13 80.43,82.25 80.21,82.25 80.09,82.36 80.09,82.6 80.21,82.71 80.43,82.71 80.55,82.83 80.55,83.06 80.43,83.18 80.21,83.18 80.09,83.3 80.09,83.53 80.21,83.65 80.43,83.65 80.55,83.77 80.55,84 80.43,84.12 80.21,84.12 80.09,84.23 80.09,84.49 80.21,84.61 80.43,84.61 80.55,84.72 80.55,84.94 80.43,85.06 80.28,85.06 80.16,85.18 80.16,85.41 80.28,85.53 81.08,85.53 85.24,89.68 85.24,89.89 85.56,90.22 85.56,92.69 85.56,92.69 85.56,93.41 86.52,94.37 v2(87.63,94.37)
  BOTTOM w0.076: UC1.AN70 92.17,95.92 91.43,95.92 91.42,95.91 89.75,95.91 88.97,95.13 87.86,95.13 87.63,94.91
  BOTTOM w0.102: 87.63,94.91 v2(87.63,94.37)
  BOTTOM w0.112: v2(80.06,57.47) 81.23,58.63 JDIMM1.21
DDR_A_D7: length 60.5
  IN3 w0.117: v2(86.71,93.51) 86.13,93.51 85.9,93.28 85.9,90.08 85.57,89.75 85.57,89.54 80.88,84.85 80.88,78.47 80.76,78.36 80.54,78.36 80.42,78.24 80.42,78.01 80.54,77.89 80.76,77.89 80.88,77.77 80.88,77.54 80.76,77.42 80.54,77.42 80.42,77.31 80.42,77.07 80.54,76.95 80.76,76.95 80.88,76.84 80.88,76.6 80.76,76.49 80.54,76.49 80.42,76.37 80.42,76.14 80.54,76.02 80.76,76.02 80.88,75.9 80.88,75.67 80.76,75.55 80.54,75.55 80.42,75.44 80.42,75.2 80.54,75.09 80.76,75.09 80.88,74.97 80.88,74.73 80.76,74.62 80.54,74.62 80.42,74.5 80.42,64.21 81.1,63.54 81.1,57.58 81.38,57.3 81.38,54.09 81.27,53.98 80.59,53.98 80.48,54.09 80.48,55.93 80.21,56.2 v2(80.06,56.2)
  BOTTOM w0.076: v2(86.71,93.51) 86.71,94.4 87.65,95.34 88.87,95.34 89.61,96.08 91.36,96.08 91.46,96.18 UC1.AN71
  BOTTOM w0.112: v2(80.06,56.2) 80.34,56.2 80.52,56.02 80.52,55.62 80.59,55.55 81.42,55.55 81.53,55.44 81.53,55.28 81.42,55.17 80.61,55.17 80.5,55.07 80.5,54.86 80.61,54.76 80.9,54.76 80.98,54.69 JDIMM1.20
DDR_A_D8: length 50.3
  IN3 w0.117: v2(87.55,92.67) 87.72,92.5 87.72,92.33 87.19,91.79 87.19,89.55 86.86,89.22 86.86,89.01 82.17,84.32 82.17,83.76 82.29,83.65 82.37,83.65 82.49,83.53 82.49,83.3 82.37,83.18 82.29,83.18 82.17,83.06 82.17,82.83 82.29,82.71 82.37,82.71 82.49,82.59 82.49,82.36 82.37,82.24 82.29,82.24 82.17,82.13 82.17,81.89 82.29,81.78 82.37,81.78 82.49,81.66 82.49,81.43 82.37,81.31 82.29,81.31 82.17,81.19 82.17,64.29 82.39,64.07 82.39,62.71 82.89,62.22 82.89,58.22 82.77,58.1 82.46,58.1 v2(82.35,58.21)
  BOTTOM w0.076: UC1.AR70 92.29,95.15 92.02,95.42 91.63,95.42 91.63,95.42 90.02,95.42 89.05,94.45 88.82,94.45
  BOTTOM w0.102: 88.82,94.45 87.55,93.18 v2(87.55,92.67)
  BOTTOM w0.112: v2(82.35,58.21) 83.12,58.21 83.23,58.32 83.23,58.51 83.15,58.59 82.96,58.59 82.84,58.71 82.84,58.87 82.96,58.99 83.15,58.99 83.23,59.07 JDIMM1.29
DDR_A_D9: length 51.5
  IN3 w0.117: v2(87.04,92.24) 86.85,92.05 86.85,89.68 86.53,89.36 86.53,89.14 81.84,84.45 81.84,66.22 81.72,66.1 81.5,66.1 81.38,65.99 81.38,65.75 81.5,65.64 81.72,65.64 81.84,65.52 81.84,65.29 81.72,65.17 81.5,65.17 81.38,65.05 81.38,64.82 81.5,64.7 81.72,64.7 81.84,64.59 81.84,64.16 82.06,63.93 82.06,62.57 82.55,62.08 82.55,61.86 82.44,61.74 82.18,61.74 82.06,61.63 82.06,61.39 82.18,61.28 82.44,61.28 82.55,61.16 82.55,60.93 82.44,60.81 82.18,60.81 82.06,60.69 82.06,60.46 82.18,60.34 82.44,60.34 82.55,60.22 82.55,59.69 v2(82.35,59.48)
  BOTTOM w0.076: UC1.AR68 93.81,95.12 93.81,95.24 93.72,95.33 93.59,95.33 93.48,95.21 93.33,95.21 93.21,95.34 93.21,95.35 93.18,95.38 93.09,95.39 93.03,95.38 92.92,95.33 92.86,95.32 92.71,95.35 92.43,95.59 91.56,95.59 91.56,95.58 89.95,95.58 89.02,94.65 88.64,94.65
  BOTTOM w0.102: 88.64,94.65 87.04,93.05 v2(87.04,92.24)
  BOTTOM w0.112: v2(82.35,59.48) 81.92,59.48 81.83,59.56 81.83,60.36 81.9,60.43 82.8,60.43 82.88,60.51 82.88,60.7 82.79,60.8 82.33,60.8 82.23,60.9 JDIMM1.25
DDR_A_D10: length 48.4
  IN3 w0.117: v2(84.89,59.48) 85.31,59.48 85.49,59.66 85.49,60.02 85.38,60.13 85.14,60.13 85.03,60.25 85.03,60.48 85.14,60.6 85.38,60.6 85.49,60.72 85.49,60.95 85.38,61.07 85.16,61.07 85.04,61.18 85.04,61.42 85.16,61.53 85.38,61.53 85.49,61.65 85.49,61.89 85.38,62 85.14,62 85.03,62.12 85.03,62.35 85.14,62.47 85.38,62.47 85.49,62.59 85.49,63.59 84.63,64.45 84.63,65.16 84.51,65.27 84.44,65.27 84.33,65.39 84.33,65.62 84.44,65.74 84.51,65.74 84.63,65.86 84.63,66.09 84.51,66.21 84.44,66.21 84.33,66.33 84.33,66.56 84.44,66.68 84.51,66.68 84.63,66.79 84.63,67.03 84.51,67.14 84.44,67.14 84.33,67.26 84.33,67.49 84.44,67.61 84.51,67.61 84.63,67.73 84.63,67.96 84.51,68.08 84.44,68.08 84.33,68.2 84.33,68.43 84.44,68.55 84.51,68.55 84.63,68.66 84.63,68.88 84.51,69 84.42,69 84.31,69.11 84.31,69.35 84.42,69.47 84.51,69.47 84.63,69.58 84.63,83.75 88.19,87.32 89.21,88.33 89.21,88.38 89.92,89.09 89.92,89.99 89.45,90.45 89.45,90.6 v2(88.85,91.2)
  BOTTOM w0.076: v2(88.85,91.2) 88.85,92.05 90.57,93.76 91.72,93.76 UC1.AU71
  BOTTOM w0.112: v2(84.89,59.48) 84.38,59.48 84.25,59.61 84.25,60.1 84.38,60.22 85.78,60.22 85.89,60.34 85.89,60.51 85.78,60.63 85.3,60.63 85.23,60.71 JDIMM1.37
DDR_A_D11: length 50.4
  IN3 w0.117: 83.16,84.19 83.16,76.9 83.04,76.79 82.95,76.79 82.83,76.67 82.83,76.44 82.95,76.32 83.04,76.32 83.16,76.2 83.16,75.97 83.04,75.85 82.95,75.85 82.83,75.74 82.83,64.57 83.06,64.35 83.06,62.99 83.55,62.49 83.55,57.8 83.13,57.38 83.13,56.87 82.98,56.72 82.98,56.3 v2(82.35,55.67)
  IN3 w0.119: v2(87.96,89.22) 87.91,89.22 87.52,88.83 87.52,88.73 83.16,84.36 83.16,84.19
  BOTTOM w0.076: 87.52,91.53 87.64,91.64 87.65,91.64 90.85,94.84 91.39,94.84 91.51,94.72 91.93,94.72 91.96,94.74 92.04,94.77 92.16,94.77 92.38,94.7 92.52,94.7 92.68,94.76 93.07,94.74 93.16,94.74 93.39,94.83 93.63,94.69 93.72,94.59 93.74,94.2 UC1.AU68
  BOTTOM w0.107: v2(87.96,89.22) 87.85,89.22 87.21,89.85 87.21,91.22 87.52,91.53
  BOTTOM w0.112: JDIMM1.24 81.98,54.62 82.35,54.99 v2(82.35,55.67)
DDR_A_D12: length 48.8
  IN3 w0.117: v2(88.64,93.48) 88.64,92.78 87.52,91.66 87.52,89.41 87.19,89.08 87.19,88.87 82.82,84.5 82.82,82.2 82.82,82.2 82.82,81.03 82.71,80.91 82.67,80.91 82.55,80.8 82.55,80.58 82.67,80.46 82.71,80.46 82.82,80.34 82.82,80.11 82.71,79.99 82.62,79.99 82.5,79.88 82.5,79.66 82.62,79.54 82.71,79.54 82.82,79.42 82.82,79.19 82.71,79.07 82.62,79.07 82.5,78.96 82.5,78.72 82.62,78.61 82.71,78.61 82.82,78.49 82.82,78.26 82.71,78.14 82.62,78.14 82.5,78.02 82.5,77.79 82.64,77.65 82.71,77.65 82.82,77.53 82.82,77.32 82.71,77.2 82.62,77.2 82.5,77.09 82.5,64.43 82.72,64.21 82.72,62.85 83.22,62.35 83.22,57.96 82.79,57.53 82.79,57.38 v2(82.35,56.94)
  BOTTOM w0.076: 89.13,94.22 90.16,95.25 91.69,95.25 UC1.AR71
  BOTTOM w0.102: 89.13,94.22 88.97,94.22 88.64,93.89 v2(88.64,93.48)
  BOTTOM w0.112: v2(82.35,56.94) 82.79,56.5 82.79,55.18 82.98,54.99 JDIMM1.28
DDR_A_D13: length 49.5
  IN3 w0.117: v2(84.89,55.67) 85.84,55.67 86.49,56.33 86.49,64 85.62,64.87 85.62,81.5 86.01,81.89 86.01,83.72 88.61,86.32 90.21,87.92 90.21,87.97 90.92,88.68 90.92,90.23 91.45,90.77 91.45,91.96 91.07,92.34 90.83,92.34 89.7,93.47 v2(89.7,94.23)
  BOTTOM w0.076: v2(89.7,94.23) 90.55,95.09 91.43,95.09 91.63,94.89 91.89,94.89 92.01,94.94 92.03,94.94 92.04,94.95 92.05,94.94 92.15,94.94 92.38,94.88 92.51,94.88 92.73,94.95 92.98,94.95 UC1.AR69
  BOTTOM w0.112: JDIMM1.38 85.48,54.62 85.34,54.75 85.34,55.22 v2(84.89,55.67)
DDR_A_D14: length 48.6
  IN3 w0.117: v2(89.32,91.58) 89.32,91.24 89.83,90.72 89.83,90.56 89.83,90.55 90.25,90.12 90.25,88.95 89.54,88.25 89.54,88.19 88.33,86.98 84.96,83.61 84.96,64.59 85.82,63.73 85.82,59.31 85.71,59.2 85.48,59.2 85.37,59.08 85.37,58.85 85.48,58.73 85.71,58.73 85.82,58.61 85.82,57.58 85.71,57.47 85.42,57.47 85.3,57.58 85.3,57.94 85.03,58.21 v2(84.89,58.21)
  BOTTOM w0.076: v2(89.32,91.58) 89.32,92.25 90.64,93.57 92.18,93.57 UC1.AU70
  BOTTOM w0.112: JDIMM1.41 86.23,59.14 86.12,59.04 85.84,59.04 85.72,58.92 85.72,58.68 85.88,58.53 85.88,58.32 85.76,58.21 v2(84.89,58.21)
DDR_A_D15: length 49.2
  IN3 w0.117: v2(84.89,56.94) 85.03,56.94 85.34,56.63 85.34,56.31 85.54,56.11 85.8,56.11 86.16,56.46 86.16,63.86 85.29,64.73 85.29,83.47 88.47,86.65 89.88,88.06 89.88,88.11 90.58,88.82 90.58,90.26 90.16,90.68 90.16,92.42 v2(90.14,92.44)
  BOTTOM w0.076: v2(90.14,92.44) 90.14,92.62 90.93,93.41 92.42,93.41 92.84,93.83 UC1.AU69
  BOTTOM w0.112: JDIMM1.42 86.48,54.79 86.37,54.89 86.18,54.89 86.08,54.99 86.08,55.19 86.18,55.29 86.37,55.29 86.48,55.4 86.48,56.16 85.69,56.94 v2(84.89,56.94)
DDR_A_D16: length 45.4
  IN3 w0.117: v2(91.21,86.31) 90.42,86.31 89.14,85.03 87.43,83.31 87.43,75.35 86.91,74.84 86.91,65.4 88.11,64.21 88.11,60.71 87.92,60.53 87.92,57.05 v2(87.17,56.31)
  BOTTOM w0.076: v2(91.21,86.31) 91.72,86.82 91.72,88.17 92.65,89.1 94.74,89.1 95.48,89.84 95.48,90.62 UC1.BB65
  BOTTOM w0.112: JDIMM1.50 88.48,55.28 88.35,55.41 87.82,55.41 87.72,55.51 87.72,55.72 87.82,55.82 88.25,55.82 88.37,55.93 88.37,56.2 88.26,56.31 v2(87.17,56.31)
DDR_A_D17: length 46.7
  IN3 w0.117: v2(92.7,87.95) 91.91,87.16 91.91,86.34 91.46,85.89 90.48,85.89 88.27,83.68 87.76,83.17 87.76,75.07 87.5,74.82 87.36,74.82 87.25,74.7 87.25,65.55 88.44,64.36 88.44,60.57 88.25,60.39 88.25,55.91 87.39,55.04 v2(87.17,55.04)
  BOTTOM w0.076: UC1.AW65 96.25,92.64 96.44,92.45 96.44,91.85 96.47,91.81 96.47,91.58 96.42,91.42 96.42,91.28 96.48,91.06 96.48,90.94 96.44,90.83 96.44,90.45 96.62,90.27 96.62,90.02 94.98,88.39 93.64,88.39 93.19,87.95 v2(92.7,87.95)
  BOTTOM w0.112: v2(87.17,55.04) 87.48,54.74 JDIMM1.46
