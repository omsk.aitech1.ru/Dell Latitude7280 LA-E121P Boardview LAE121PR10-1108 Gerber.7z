# Allegro board LAE121PR10-1108.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on VCC: 276.77,1.17 276.77,45.39 276.64,46.03 276.28,46.57 275.09,47.77 282.6,55.28 282.6,88.52 282.67,88.59 288.17,88.59 289.39,89.82 289.39,90.43 299.03,90.43 299.03,89.92 296.35,89.92 296.35,86.87 288.59,86.87 286.77,87.25 285.73,85.7 285.73,72.1 286.77,70.55 288.59,70.93 296.35,70.93 296.35,70.62 293.9,70.62 292.86,70.19 292.43,69.15 292.43,66.75 292.86,65.71 293.9,65.28 299.53,65.28 299.53,51.3 299.5,51.3 298.32,50.81 297.83,49.63 297.83,48.03 297.87,47.69 297.97,47.37 295.9,47.37 295.42,47.29 295,47.06 294.62,47.45 281.31,47.45 279.81,45.94 279.81,33.27 283.03,30.05 298.33,30.05 298.33,23.67 293.9,23.67 292.86,23.24 292.43,22.2 292.43,1.17 ; 1 cut-out
GND on VCC: 6.32,109.42 6.32,111.62 5.28,113.17 3.46,112.79 1.57,112.79 1.57,114.46 2.43,114.96 2.77,115.9 2.77,116.93 9.58,116.93 9.58,116.5 9.96,115.18 10.99,114.27 8.15,111.43 8.15,109.91 7.67,109.42
GND on VCC: 4.92,36.27 5.54,36.81 5.77,37.6 5.77,40 5.34,41.04 4.3,41.47 2.77,41.47 2.77,52.53 3.55,53.06 3.85,53.95 3.85,54.48 11.61,54.48 13.43,54.1 14.47,55.65 14.47,69.25 13.43,70.8 11.61,70.42 3.85,70.42 3.85,70.73 4.3,70.73 5.34,71.16 5.77,72.2 5.77,74.6 5.34,75.64 4.3,76.07 1.17,76.07 1.17,76.73 9.9,76.73 11.45,77.77 11.07,79.59 11.07,91.61 11.45,93.43 9.9,94.47 1.17,94.47 1.17,94.5 1.47,94.96 1.57,95.5 1.57,101.51 3.46,101.51 5.28,101.13 6.32,102.67 6.32,104.91 7.26,104.91 7.39,104.79 12.51,104.79 12.91,105.19 12.91,108.17 14.1,109.36 16.79,109.36 16.79,109.04 18.12,107.71 18.12,103.88 17.3,103.05 17.3,99.71 17.55,99.45 17.55,98.69 17.36,98.5 14.4,98.5 13.8,97.91 13.8,73.18 17.42,69.57 17.42,54.41 16.92,53.9 16.92,51.28 17.57,50.62 36.37,50.62 37.31,49.68 33.45,49.38 33.27,45.52 33.02,45.08 32.93,44.58 32.93,36.27 31.52,36.27 31.52,40 30.48,41.55 28.66,41.17 10.74,41.17 8.92,41.55 7.88,40 7.88,36.27 ; 1 cut-out
GND on IN2: 89.11,105.42 89.24,105.29 89.24,104.79 88.67,104.21 82.13,104.21 79.4,101.48 74.19,101.48 74,101.67 74,104.34 74.26,104.6 76.22,104.6 77.05,105.42
GND on GND2: outline of 392 points within 0.21,0.21 300.49,136.99
GNDA on TOP (solid shape): 266.53,58.43 266.53,57.8 265.96,57.8 265.96,57.29 266.53,57.29 266.53,56.84 266.22,56.53 264.37,56.53 264.37,58.62 266.34,58.62
GNDA on TOP (solid shape): 252.68,55.36 252.68,54.27 252.83,54.12 254.15,54.12 254.4,54.37 255.61,54.37 255.61,52.15 255.34,51.88 251.12,51.88 251.1,51.89 251.1,53.5 251.05,53.55 251.05,55 251.31,55.26 252.12,55.26 252.27,55.41 252.63,55.41
GNDA on BOTTOM (solid shape): 291.06,41.79 291.06,40.78 290.9,40.63 289.41,40.63 289.25,40.78 289.25,41.92 289.56,42.23 290.63,42.23
GNDA on BOTTOM (solid shape): 285.72,31.25 286.54,31.25 286.61,31.33 286.61,31.79 286.89,32.07 288.14,32.07 288.39,31.81 288.39,31.25 287.83,30.69 283.26,30.69 283.01,30.95 283.01,31.99 283.56,32.55 284.43,32.55
GNDA on GND1: 251.1,49.29 251.1,56.41 249.83,57.68 249.83,61.4 251.1,62.67 251.1,63.05 251.18,63.13 254.2,63.13 254.72,62.61 254.72,57.73 258.41,57.73 258.41,56.99 258.34,56.92 258.34,56.76 259.49,55.62 259.49,53.78 259.85,53.41 262.42,53.41 262.79,53.78 262.79,56.41 262.49,56.72 261.28,56.72 261.14,56.86 261.14,58.26 261.02,58.37 260.93,58.37 260.81,58.49 259.93,58.49 259.93,59.38 260.9,59.38 261.14,59.19 261.14,59.11 261.25,59 261.69,59 262.14,58.56 266.2,58.56 269.39,55.37 269.39,53.43 265.25,49.29
GNDA on GND1: 283.19,30.43 280.19,33.43 280.19,45.78 281.47,47.06 294.46,47.06 295.43,46.09 295.4,46 295.39,45.9 295.39,43.5 295.54,43.14 295.9,42.99 299,42.99 299.21,42.91 299.29,42.7 299.29,40.75 299.21,40.54 299,40.46 286.6,40.46 285.9,39.85 286.39,39.07 286.39,33.63 285.9,32.85 286.6,32.24 299,32.24 299.21,32.16 299.29,31.95 299.29,30.43
GNDA on VCC: 251.1,49.32 251.1,56.41 249.83,57.68 249.83,61.4 251.1,62.67 251.1,63.05 251.18,63.13 254.2,63.13 254.72,62.61 254.72,57.73 258.41,57.73 258.41,56.99 258.34,56.92 258.34,56.76 259.49,55.62 259.49,53.78 259.85,53.41 262.42,53.41 262.79,53.78 262.79,56.41 262.49,56.72 261.28,56.72 261.14,56.86 261.14,58.26 261.02,58.37 260.93,58.37 260.81,58.49 259.93,58.49 259.93,59.38 260.9,59.38 261.14,59.19 261.14,59.11 261.25,59 261.69,59 262.14,58.56 266.2,58.56 269.39,55.37 269.39,53.43 267.55,51.59 267.55,49.56 267.31,49.32
GNDA on VCC: 283.19,30.43 280.19,33.43 280.19,45.78 281.47,47.06 294.46,47.06 294.73,46.79 294.51,46.37 294.43,45.9 294.43,43.5 294.86,42.46 295.9,42.03 298.33,42.03 298.33,41.42 286.6,41.42 285.05,40.38 285.43,38.56 285.43,34.14 285.05,32.32 286.6,31.28 298.33,31.28 298.33,30.43
GNDA on GND2: 283.19,30.43 280.19,33.43 280.19,44.92 271.57,53.54 269.5,53.54 265.25,49.29 251.1,49.29 251.1,56.41 249.83,57.68 249.83,61.4 251.1,62.67 251.1,63.05 251.18,63.13 254.2,63.13 254.72,62.61 254.72,57.73 258.41,57.73 258.41,56.99 258.34,56.92 258.34,56.76 259.49,55.62 259.49,53.78 259.85,53.41 262.42,53.41 262.79,53.78 262.79,56.41 262.49,56.72 261.28,56.72 261.14,56.86 261.14,58.26 261.02,58.37 260.93,58.37 260.81,58.49 259.93,58.49 259.93,59.38 260.9,59.38 261.14,59.19 261.14,59.11 261.25,59 261.69,59 262.14,58.56 266.2,58.56 267.34,57.41 273.25,57.41 283.66,47 294.52,47 295.43,46.09 295.4,46 295.39,45.9 295.39,43.5 295.54,43.14 295.9,42.99 299,42.99 299.21,42.91 299.29,42.7 299.29,40.75 299.21,40.54 299,40.46 286.6,40.46 285.9,39.85 286.39,39.07 286.39,33.63 285.9,32.85 286.6,32.24 299,32.24 299.21,32.16 299.29,31.95 299.29,30.43
VCCSA_B+ on TOP (solid shape): 65.18,113.78 65.02,113.63 63.93,113.63 63.78,113.78 63.78,115.02 65.18,115.02
VCCSA_B+ on BOTTOM (solid shape): 65.65,114.54 68.35,114.54 68.35,114.01 67.73,114.01 67.64,113.92 67.64,112.91 67.38,112.66 64.49,112.66 64.49,113.22 63.96,113.22 63.96,112.66 63.73,112.66 63.73,114.96 63.78,115.01 65.18,115.01
VIN_1.8VALW on BOTTOM (solid shape): 170.81,67.3 170.81,66.51 171.27,66.05 171.27,65.75 171.07,65.54 170.38,65.54 168.4,67.52 168.4,67.55 169.11,68.26 169.85,68.26
VIN_1V_PRIM on TOP (solid shape): 161.22,129.49 161.22,129.17 161.41,128.98 161.98,128.98 162.04,128.92 162.04,128.41 161.98,128.34 160.2,128.34 160.08,128.47 160.08,129.49 160.2,129.61 161.09,129.61
VIN_1V_PRIM on BOTTOM (solid shape): 161.19,129.49 161.19,129.11 161.31,128.98 161.95,128.98 162.01,128.92 162.01,128.22 161.89,128.09 160.95,128.09 160.77,127.91 160.77,126.58 160.69,126.5 159.41,126.5 158.58,127.33 158.58,128.53 158.71,128.66 159.6,128.66 159.92,128.98 159.92,129.49 160.04,129.61 161.06,129.61
VIN_1VS_VCCIO on TOP (solid shape): 145.25,131.01 145.25,130.69 145.5,130.44 146.07,130.44 146.07,129.93 146.01,129.87 144.23,129.87 144.17,129.93 144.17,130.95 144.3,131.07 145.19,131.07
VIN_1VS_VCCIO on BOTTOM (solid shape): 145.31,130.95 145.31,130.63 145.44,130.5 146.01,130.5 146.07,130.44 146.07,129.74 145.95,129.61 145.22,129.61 144.88,129.27 144.88,128.03 143.53,128.03 142.71,128.85 142.71,130.06 142.71,130.09 142.8,130.19 143.72,130.19 144.04,130.5 144.04,130.95 144.17,131.07 145.19,131.07
+AC_IN on TOP (solid shape): 48.89,105.5 48.89,103.8 48.77,103.67 48.18,103.67 47.47,102.96 45.46,102.96 45.44,102.98 45.44,103.44 45.3,103.58 45.3,105.04 45.31,105.05 45.31,105.34 45.62,105.65 48.74,105.65
+AC_IN on TOP (solid shape): outline of 310 points within 29.57,112.72 43.99,120.6
+AC_IN on IN2 (solid shape): 39.9,115.64 41.62,115.64 41.81,115.45 41.81,113.42 41.62,113.23 39.1,113.23 38.96,113.37 37.86,113.37 36.66,114.56 34.31,114.56 33.3,115.58 32.28,115.58 32.09,115.77 32.09,117.68 32.41,117.99 37.55,117.99
+AC_IN on VCC: 45.4,103.39 39.78,109.02 39.78,115.16 40.52,115.9 45.26,115.9 48.47,112.68 48.47,104.07 47.8,103.39
+BL_PWR_SRC on TOP (solid shape): 47.59,128.09 47.59,127.39 46.51,126.31 46.51,122.12 46.38,121.99 45.11,121.99 44.98,122.12 44.98,125.74 45.14,125.9 45.14,127.11 46.51,128.47 47.2,128.47
+BL_PWR_SRC on TOP (solid shape): 58.13,133.11 59.02,133.11 59.27,132.85 60.79,132.85 60.96,132.69 60.96,131.8 60.4,131.24 59.08,131.24 58.29,132.03 57.73,132.03 57.71,132.05 57.21,132.05 56.98,132.28 56.58,132.28 56.4,132.46 56.4,133.6 56.67,133.87 57.36,133.87
+BL_PWR_SRC on BOTTOM (solid shape): 60.37,133.28 60.37,132 60.54,131.84 60.54,131.39 60.41,131.27 58.96,131.27 58.84,131.39 58.84,131.81 59.13,132.1 59.13,133.28 59.21,133.36 60.3,133.36
+CHARGER_SRC on TOP (solid shape): 47.97,79.39 49.24,79.39 49.55,79.07 49.55,72.78 49.11,72.34 47.01,72.34 46.63,71.96 46.63,71.38 46.19,71.38 46.19,75.51 45.81,75.89 45.81,79.83 45.55,80.08 45.55,80.67 45.59,80.71 46.65,80.71
+CHARGER_SRC on BOTTOM (solid shape): 49.24,83.96 48.72,83.96 48.72,83.25 49.24,83.25 49.24,82.76 48.72,82.76 48.72,82.05 49.24,82.05 49.24,80.49 49.73,79.99 50.71,79.99 50.89,79.81 50.89,73.54 50.82,73.48 46.06,73.48 45.81,73.73 45.81,79.83 45.55,80.08 45.55,84.15 45.81,84.4 48.37,84.4 48.47,84.5 49.24,84.5
+DC_IN on BOTTOM (solid shape): 46.89,121.11 47.33,120.66 47.33,118.5 47.26,118.43 41.82,118.43 41.74,118.5 41.74,119.26 41.81,119.33 42.51,119.33 42.89,119.71 42.89,121.17 43.39,121.68 46.89,121.68
+DC_IN_SS on BOTTOM (solid shape): 52.78,119.04 52.78,117.33 52.63,117.18 49.58,117.18 48.94,116.55 48.94,113.24 48.77,113.07 44.59,113.07 44.42,113.12 44.26,113.07 44.19,113.07 43.89,113.37 43.89,115.4 44.17,115.68 44.17,116.32 44.83,116.98 44.83,117.59 45.01,117.77 47.55,117.77 48.97,119.19 52.63,119.19
+DCIN_JACK on BOTTOM (solid shape): 41.92,121.74 42.01,121.71 42.09,121.69 42.11,121.69 42.32,121.49 42.32,119.84 42.06,119.58 41.74,119.58 41.49,119.33 41.49,118.44 41.3,118.25 39.27,118.25 39.08,118.06 36.66,118.06 36.47,118.25 36.47,121.4 36.82,121.74 41.84,121.74
+EC_DEBUG_VCC on BOTTOM (solid shape): 290.29,126.58 291.32,126.58 291.4,126.5 291.4,126.26 291.3,126.15 289.98,126.15 289.74,126.39 289.19,126.39 288.84,126.75 288.84,127.41 288.88,127.46 289.41,127.46
+EDP_VDD on TOP (solid shape): 67.97,126.95 67.97,124.92 67.65,124.6 66.7,124.6 66.52,124.78 66.52,125.61 65.86,126.27 65.86,127.71 67.21,127.71
+LCDVDD on TOP (solid shape): 69.81,134.5 69.81,132.66 68.73,131.58 66.25,131.58 66.19,131.52 66.19,130.95 65.95,130.7 65.95,128.03 65.68,127.77 65.68,127.46 65.11,127.46 65.11,126.95 65.68,126.95 65.68,126.69 64.6,126.69 64.41,126.88 64.41,131.14 64.79,131.51 64.79,132.39 64.9,132.5 64.92,132.5 65.47,133.04 65.94,133.04 66.38,133.49 66.38,134.57 66.57,134.76 69.56,134.76
+LCDVDD on BOTTOM (solid shape): 66.38,133.3 66.38,132.03 66.57,131.84 66.57,131.2 66.13,130.76 66.13,129.74 66,129.61 64.79,129.61 64.67,129.74 64.67,131.58 64.92,131.84 65.43,131.84 65.62,132.03 65.62,133.3 65.68,133.36 66.32,133.36
+PBATT on TOP (solid shape): outline of 107 points within 170.2,55.26 177.96,60.78
+PWR_SRC on TOP (solid shape): 44.54,123.33 44.54,121.93 44.28,121.68 41.89,121.68 41.89,122.24 41.82,122.48 41.64,122.67 41.6,122.74 41.63,122.83 41.81,123.01 43.46,123.01 43.9,123.45 44.41,123.45
+PWR_SRC on TOP (solid shape): 71.59,81.1 74.76,81.1 75.59,80.27 75.59,76.27 75.14,75.83 73.56,75.83 72.73,76.66 63.99,76.66 63.67,76.34 63.67,74.18 63.64,74.15 63.63,74.15 63.42,74.05 63.27,73.87 63.27,73.86 62.57,73.16 62.57,66.75 62.13,66.3 58.7,66.3 58.7,65.35 58.25,65.35 58.25,69.61 58.83,70.18 58.83,70.33 58.83,76.78 59.02,76.97 59.02,80.08 60.48,81.54 71.14,81.54
+PWR_SRC on TOP (solid shape): 171.22,53.35 171.22,52.41 170.69,52.41 170.67,52.39 170.65,52.38 170.34,52.03 170.65,51.68 170.67,51.67 170.69,51.65 171.14,51.65 171.17,51.62 171.17,50.19 170.84,49.86 164.74,49.86 164.43,50.18 164.43,52.75 165.34,53.67 170.9,53.67
+PWR_SRC on BOTTOM (solid shape): 181.36,50.94 183.9,50.94 184,50.84 184,49.84 184.25,49.59 184.25,49.54 184.05,49.34 180.3,49.34 180.05,49.59 180.05,50.5 180.49,50.94 181.36,50.94
+PWR_SRC on BOTTOM (solid shape): 39.01,130.57 39.01,129.75 38.75,129.13 39.36,128.85 39.39,128.86 39.74,128.5 42.85,128.5 43.54,127.82 43.54,124.36 43.47,124.1 43.54,123.85 43.54,122.07 43.46,121.99 41.94,121.99 41.84,122.09 41.85,122.12 41.86,122.29 41.81,122.46 41.81,126.31 41.52,126.6 39.3,126.6 39.14,126.76 39.14,127.52 37.87,128.79 37.87,130.5 38.06,130.69 38.89,130.69
+PWR_SRC on BOTTOM (solid shape): outline of 1607 points within 57.98,49.86 169,82.82
+PWR_SRC on IN1 (solid shape): outline of 167 points within 164.36,49.34 182.47,52.87
+PWR_SRC on IN2 (solid shape): 44.28,121.49 44.28,120.34 44.16,120.22 43.39,120.22 41.87,121.74 41.87,122.31 42,122.44 43.33,122.44
+PWR_SRC on IN2 (solid shape): 58.14,119.42 58.14,118.57 58.65,118.05 58.65,117.46 58.37,117.18 57.23,117.18 56.55,117.86 56.55,118.64 56.23,118.95 56.23,119.64 56.59,120 57.56,120
+PWR_SRC on IN3 (solid shape): 58.74,118.06 58.74,116.52 58.58,116.37 57.24,116.37 57.24,118.06 57.36,118.18 58.61,118.18
+PWR_SRC on IN3 (solid shape): 58.76,81.99 58.76,80.4 58.57,80.21 57.43,80.21 56.86,80.78 56.86,82.31 57.43,82.88 57.87,82.88
+PWR_SRC on IN3 (solid shape): outline of 190 points within 164.36,49.34 182.47,52.08
+PWR_SRC_AC on TOP (solid shape): 54.13,84.15 54.13,80.53 53.81,80.21 50.63,80.21 50.44,80.4 50.44,82.93 50.98,82.93 51.33,83.28 50.98,83.64 50.44,83.64 50.44,84.34 50.57,84.47 53.81,84.47
+PWR_SRC_AC on BOTTOM (solid shape): 49.92,84.4 53.82,84.4 54.11,84.12 54.11,80.52 53.8,80.21 49.81,80.21 49.4,80.62 49.4,82.18 48.85,82.18 48.85,82.63 49.4,82.63 49.4,83.38 48.85,83.38 48.85,83.83 49.4,83.83 49.4,84.51 49.4,84.52 49.81,84.52
+REGCTL_PNP10 on TOP (solid shape): 246.58,123.43 246.58,122.08 246.91,121.75 246.91,121.09 246.79,120.97 246.3,120.97 246.18,121.09 246.18,121.52 246.3,121.73 246.21,121.96 246.21,122.19 246.38,122.36 246.38,123.43 246.43,123.48 246.53,123.48
+REGCTL_PNP10 on BOTTOM (solid shape): 252.2,125.35 252.2,124.24 251.65,123.68 250.89,123.68 250.54,124.03 250.54,125.28 250.68,125.42 252.13,125.42
+REGCTL_PNP10 on IN3 (solid shape): 251.66,124.38 251.66,123.64 250.58,122.57 247.86,122.57 247.1,121.8 247.1,121.04 246.91,120.85 246.15,120.85 245.83,121.17 245.83,122.57 247.35,124.08 250.22,124.08 250.8,124.67 251.36,124.67
+RTC_CELL on TOP (solid shape): outline of 311 points within 119.68,89.76 124.68,97.86
+SDC_IN on TOP (solid shape): 52.35,111.45 52.35,109.48 52.03,109.17 50.25,109.17 50.06,109.36 50.06,109.93 49.87,110.12 48.79,110.12 48.67,109.99 48.67,109.36 47.2,109.36 47.14,109.42 47.14,111.2 47.97,112.02 51.78,112.02
+SDC_IN on TOP (solid shape): 51.33,86.43 51.33,84.91 51.14,84.72 50.07,84.72 49.43,84.08 49.43,83.67 48.89,83.67 48.86,83.64 48.85,83.64 48.54,83.28 48.85,82.93 48.86,82.93 48.89,82.9 49.31,82.9 49.35,82.86 49.35,82.18 46.7,82.18 45.81,83.07 45.81,86.12 46.32,86.62 51.14,86.62
+SDC_IN on BOTTOM (solid shape): 52.75,116.39 52.75,111.57 51.95,111.57 51.59,111.2 51.59,110.4 51.01,109.83 51.01,105.23 47.71,105.23 47.71,106.42 47.7,106.44 47.7,106.79 47.42,107.07 46.23,107.07 45.74,106.59 45.21,106.59 44.98,106.82 44.98,107.63 45.21,107.86 46,107.86 46.23,108.09 46.23,108.6 45.97,108.85 44.91,108.85 44.7,108.65 44.04,108.65 44.04,109.18 44.12,109.26 45.83,109.26 46.06,109.48 46.06,110.06 46.44,110.44 46.44,111.2 46.23,111.42 46.23,112.32 46.32,112.41 48.73,112.41 49.43,113.1 49.43,116.41 49.49,116.47 52.68,116.47
+SDC_IN on IN2 (solid shape): outline of 2385 points within 45.68,84.4 56.79,111.9
+SDREG2 on TOP (solid shape): 279.07,66.88 278.34,66.88 277.77,66.3 277.77,66.23 277.72,66.18 276.96,66.18 276.88,66.25 276.88,66.33 276.93,66.38 277.09,66.38 277.95,67.24 279.07,67.24
+TBT_SVR_IND on TOP (solid shape): 25.44,97.09 25.44,96.93 25.52,96.85 25.57,96.8 25.62,96.79 25.68,96.78 25.76,96.7 25.76,96.44 25.72,96.4 25.72,95.48 25.37,95.14 25.37,95.13 25.35,95.11 25.35,94.51 24.59,93.74 24.13,93.29 24.13,91.12 22.71,91.12 22.71,94.83 23.09,94.83 24.33,96.08 24.74,96.08 25.02,96.36 25.02,96.81 25.09,96.89 25.09,97.06 25.17,97.14 25.39,97.14
+TBTA_VBUS on TOP (solid shape): 24.15,116.79 24.15,114.06 23.84,113.74 23.39,113.74 23.14,113.49 23.14,112.91 20.47,112.91 19.52,113.87 16.79,113.87 16.41,114.25 16.41,116.6 16.72,116.91 24.03,116.91
+TBTA_VBUS on TOP (solid shape): 7.29,108.57 8.38,108.57 8.47,108.66 9.77,108.66 9.85,108.57 9.85,108.24 9.78,108.16 8.43,108.16 8.36,108.24 7.16,108.24 7.09,108.16 6.4,108.16 6.27,108.29 6.27,108.67 6.45,108.85 7.01,108.85
+TBTA_VBUS on TOP (solid shape): 7.14,106.06 8.38,106.06 8.47,106.14 9.5,106.14 9.57,106.07 9.57,105.73 9.5,105.65 8.43,105.65 8.34,105.74 7.18,105.74 6.88,105.45 6.42,105.45 6.3,105.57 6.3,106.03 6.42,106.16 7.03,106.16
+TBTA_VBUS on BOTTOM (solid shape): 10.06,105.93 10.06,104.91 9.23,104.91 8.48,105.66 8.48,105.97 8.62,106.11 9.88,106.11
+TBTA_VBUS on IN2 (solid shape): outline of 315 points within 6.32,105.42 22.19,116.6
+TBTA_VBUS on VCC: 6.32,105.42 6.32,108.91 7.88,108.91 8.66,109.7 8.66,111.22 11.43,113.99 13.15,113.99 14.82,115.67 14.82,116.93 22.25,116.93 22.25,114.42 21.95,114.12 20.87,114.12 16.62,109.87 13.89,109.87 12.41,108.38 12.41,105.4 12.3,105.29 7.64,105.29 7.52,105.42
+TBTA_VBUS_1 on TOP (solid shape): 29.11,121.18 29.11,118.86 29.41,118.56 29.41,116.28 29.96,116.28 29.96,115.83 29.42,115.83 29.42,115.08 29.96,115.08 29.96,114.63 29.42,114.63 29.42,112.97 29.36,112.91 25.81,112.91 25.81,113.55 25.68,113.68 25.17,113.68 25.04,113.8 25.04,116.85 25.23,117.04 25.32,117.04 26.12,117.84 26.12,121.04 26.31,121.23 29.06,121.23
+TBTA_VBUS_1 on BOTTOM (solid shape): 18.57,78.88 18.57,75.39 18.25,75.07 16.47,75.07 16.22,75.32 16.22,77.86 16.03,78.05 16.03,78.62 16.47,79.07 18.38,79.07
+TBTA_VBUS_1 on TOP: 30.1,77.49 30.06,77.46 30.03,77.44 29.59,77 29.49,77 29.23,76.74 29.23,76.26 29.13,76.16 28.29,76.16 28.22,76.24 28.22,77.8 28.26,77.84 28.62,77.84 28.77,77.99 28.98,77.99 29.36,78.37 29.36,78.56 29.42,78.62 29.68,78.62 29.81,78.75 29.81,79.07 29.87,79.13 30.14,79.13 30.25,79.02 30.25,78.75 30.38,78.62 30.57,78.62 30.6,78.59 30.6,77.99
+TBTA_VBUS_1 on IN2: 29.81,78.94 28.98,79.77 16.92,79.77 15.96,78.81 15.96,76.08 17.42,74.62 28.85,74.62 31.58,77.35 32.9,77.35 34.1,78.55 34.56,78.55 34.7,78.69 34.7,79 34.57,79.13 33.81,79.13 33.62,78.94
+TBTA_VBUS_1 on IN2: 17.3,103.33 17.3,102.37 17.49,102.18 19.07,102.18 25.11,108.21 25.11,112.41 26.69,113.99 26.69,117.3 26.38,117.61 26.06,117.61 25.23,116.79 23.27,116.79 22.53,116.06 22.53,107.87 18.19,103.52 17.49,103.52
+TBTA_VBUS_1 on IN3: 14.25,99.39 15.68,100.82 15.68,101.77 17.17,103.26 18.38,103.26 18.63,103.01 18.63,102.06 18.69,101.99 22.76,101.99 23.2,102.44 23.2,107.2 22.47,107.93 22.47,116.37 22.88,116.79 25.3,116.79 26.06,117.55 26.63,117.55 26.76,117.42 26.76,114.06 25.36,112.66 25.36,105.61 24.49,104.74 24.49,101.56 23.72,100.8 20.8,100.8 19.93,99.93 19.93,91.8 17.99,89.86 17.99,76.91 17.68,76.59 14.69,76.59 14.31,76.97 14.31,91.42 15.11,92.21 15.11,92.88 14.25,93.74
+USB_EX2_PWR on TOP (solid shape): 19.65,67.45 19.65,65.35 15.65,65.35 15.33,65.67 15.33,67.19 15.71,67.57 19.52,67.57
+USB_EX2_PWR on BOTTOM (solid shape): 20.09,58.11 20.09,56.4 20.31,56.18 20.31,55.23 20.19,55.12 18.58,55.12 18.25,55.45 18.25,57.92 18.5,58.18 20.03,58.18
+USB_EX2_PWR on IN2 (solid shape): 19.96,67 19.96,55.83 19.65,55.51 18.19,55.51 17.93,55.76 17.93,64.78 17.36,65.35 15.71,65.35 15.33,65.73 15.33,66.18 16.6,67.45 19.52,67.45
+UZ12_TPM on BOTTOM (solid shape): 162.85,115.96 162.85,112.7 162.24,112.09 160.76,112.09 160.69,112.15 160.69,113.26 161.16,113.73 161.16,115.3 161.21,115.35 161.21,116.05 161.31,116.15 162.66,116.15
+VCHGR on TOP (solid shape): 177.06,54.56 177.06,53.46 177.95,52.57 177.95,51.24 174.47,51.24 174.46,51.26 172.24,51.26 172.24,51.67 172.78,51.67 173.14,52.03 172.78,52.39 172.24,52.39 172.24,53.48 172.49,53.73 174.52,53.73 174.78,53.99 174.78,54.56 174.9,54.68 176.94,54.68
+VHDMI_VCC on TOP (solid shape): 15.14,89.29 16.09,89.29 16.22,89.16 16.22,88.47 16.34,88.34 17.04,88.34 17.04,87.83 16.41,87.83 16.15,88.09 14.69,88.09 13.59,89.19 12.88,89.19 12.7,89.37 12.7,89.93 13.11,90.33 14.1,90.33
+VHDMI_VCC on BOTTOM (solid shape): 15.75,90.4 16.1,90.4 16.88,89.62 17.52,89.62 18.06,89.09 18.59,89.09 18.74,88.94 18.74,88.15 18.57,87.97 18.03,87.97 17.54,88.47 16.47,88.47 16.22,88.21 15.77,88.21 15.65,88.34 15.65,88.85 15.33,89.16 15.33,90.31 15.43,90.41 15.75,90.41
BOOT1_ISL88738 on TOP (solid shape): 57.48,60.92 57.2,60.92 56.69,60.41 56.69,59.83 56.82,59.7 56.82,58.68 56.77,58.63 56.67,58.63 56.62,58.68 56.62,59.47 56.34,59.75 56.34,60.82 56.62,61.1 56.62,61.53 57.48,61.53
BOOT2_ISL88738 on TOP (solid shape): 61.11,56.4 60.48,56.4 60.25,56.63 59.31,56.63 59.21,56.73 58.16,56.73 58.11,56.78 58.11,56.88 58.16,56.93 60.12,56.93 60.48,57.29 61.11,57.29
BST_3V on BOTTOM (solid shape): 155.47,74.28 155.47,73.52 155.85,73.14 156.72,73.14 156.82,73.04 156.82,72.22 156.79,72.2 155.95,72.2 155.22,72.93 155.22,74.26 155.29,74.33 155.42,74.33
BST_5V on BOTTOM (solid shape): 185.95,54.47 185.95,53.96 185.98,53.96 186.97,52.97 186.97,51.32 186.92,51.27 186.13,51.27 186.02,51.38 186.02,53.36 185.7,53.68 185.7,54.44 185.77,54.52 185.9,54.52
BST_+1VALWP on TOP (solid shape): 154.41,85.18 154.41,83.45 154.36,83.39 153.61,83.39 153.24,83.76 153.24,85.19 153.39,85.34 154.26,85.34
BST_+1VALWP on BOTTOM (solid shape): 154.42,85.23 154.42,84.44 154.34,84.36 153.76,84.36 153.73,84.34 153.32,84.34 153.24,84.42 153.24,85.22 153.38,85.35 154.29,85.35
BST_+1VALWP_C on TOP (solid shape): 156.73,83.4 155.14,83.4 155.14,84.29 156.73,84.29
CORE_SNUB on BOTTOM (solid shape): 59.5,104.58 59.5,101.66 59.35,101.51 58.48,101.51 58.33,101.66 58.33,104.51 58.48,104.65 59.42,104.65
CORE_SW on BOTTOM (solid shape): 64.06,109.14 64.06,107.81 61.54,107.81 61.54,106.97 64.06,106.97 64.06,104.81 62.13,102.88 62.13,101.69 61.96,101.52 60.18,101.52 59.84,101.86 59.84,106.04 59.38,106.5 58.89,106.5 58.57,106.82 58.23,106.82 58.16,106.88 58.16,109.18 58.22,109.23 63.97,109.23
CPU_B+ on TOP (solid shape): 54.82,110.15 54.82,106.31 55.27,105.87 55.27,103.01 55.14,102.88 53.43,102.88 53.17,103.13 53.17,110.15 53.31,110.29 54.68,110.29
CPU_B+ on TOP (solid shape): 64.35,87.26 65.75,87.26 65.75,87.83 66.51,87.83 66.76,87.58 66.76,83.49 66.6,83.32 63.8,83.32 63.65,83.48 63.65,87.58 63.91,87.83 64.35,87.83
CPU_B+ on BOTTOM (solid shape): 64.98,112.34 64.98,111.45 64.86,111.33 63.59,111.33 63.46,111.45 63.46,112.34 63.59,112.47 64.86,112.47
CPU_B+ on BOTTOM (solid shape): 67.46,88.21 67.46,83.32 66.83,82.69 63.93,82.69 63.93,82.69 59.84,82.69 59.59,82.94 59.59,85.48 59.84,85.74 61.14,85.74 61.62,86.22 61.62,86.43 62.38,87.2 62.38,88.4 62.64,88.66 67.02,88.66
CPU_B+ on BOTTOM (solid shape): 55.55,109.21 55.55,104.68 55.27,104.4 55.27,103.01 55.14,102.88 53.68,102.88 53.17,103.39 53.17,108.47 53.43,108.72 54.13,108.72 54.63,109.23 55.52,109.23
CPU_B+ on VCC: 63.12,83.32 56.92,89.52 56.92,92.57 54.89,94.6 54.89,97.72 53.62,98.99 53.62,102.99 53.17,103.43 53.17,106.9 58.74,112.47 64.86,112.47 64.86,109.21 63.46,107.81 63.46,97 66.71,93.74 66.76,93.2 67.3,93.15 67.57,92.88 67.48,92.56 67.8,92.66 69.49,90.96 69.49,85.97 66.85,83.32 ; 1 cut-out
EN_1.8VALW on BOTTOM (solid shape): 175.54,66.3 175.54,66.23 174.34,65.03 173.94,65.03 173.51,65.47 173.51,67.52 173.91,67.93
GPU_B+ on TOP (solid shape): 67.52,88.4 67.14,88.02 62.38,88.02 62.13,88.28 62.13,90.12 62.32,90.31 64.16,90.31 64.35,90.5 64.35,90.56 67.52,90.56
GPU_B+ on BOTTOM (solid shape): 67.55,90.85 67.55,89.32 67.17,88.94 61.53,88.94 61.16,89.3 61.16,91.1 61.19,91.12 67.28,91.12
GT_SNUB1 on TOP (solid shape): 64.48,95.26 63.65,95.26 63.27,94.88 61.56,94.88 61.56,95.9 64.48,95.9
GT_SW1 on TOP (solid shape): 63.21,96.72 63.02,96.53 61.81,96.53 61.56,96.78 61.56,98.56 63.21,98.56
GT_SW1 on BOTTOM (solid shape): 64.39,100.62 64.39,99.32 64.36,99.3 61.85,99.3 61.85,98.46 64.36,98.46 64.36,94.11 63.97,93.71 61.19,93.71 61.19,95.54 60.53,96.2 60.53,100.44 61.12,101.04 63.97,101.04
HDMI_OB on TOP (solid shape): 18.12,80.02 18.38,79.77 18.38,78.69 18.19,78.5 17.61,78.5 17.42,78.69 17.42,87.13 17.55,87.26 18.12,87.26
INT_SPK_L+ on TOP (solid shape): 279.61,24.08 280.12,24.08 280.12,22.36 279.61,22.36 279.49,22.49 279.49,22.81 278.54,23.76 278.54,24.65 279.04,24.65
INT_SPK_L+ on TOP (solid shape): 265.35,60.95 265.35,59.95 262.91,59.95 262.79,59.83 261.33,59.83 261.12,60.03 259.97,60.03 259.92,60.08 259.92,60.18 259.97,60.23 262.63,60.23 263.37,60.97 265.33,60.97
INT_SPK_L- on TOP (solid shape): 279.68,26.11 280.06,26.11 280.12,26.05 280.12,24.39 279.61,24.39 279.55,24.46 279.55,24.78 278.66,25.66 278.66,26.24 278.92,26.49 279.3,26.49
INT_SPK_L- on TOP (solid shape): 265.17,61.1 263.3,61.1 262.58,60.39 260.88,60.39 260.83,60.44 259.94,60.44 259.92,60.46 259.92,60.59 259.97,60.64 262.23,60.64 263.7,62.11 263.83,62.11 263.83,62.11 265.17,62.11
INT_SPK_R+ on TOP (solid shape): 280.12,21.47 280.12,20.33 278.85,20.33 278.73,20.46 278.73,21.54 278.92,21.73 279.87,21.73
INT_SPK_R+ on TOP (solid shape): 262.71,62.19 262.71,61.86 262.61,61.76 261.74,61.76 261.2,61.22 259.97,61.22 259.92,61.28 259.92,61.4 259.97,61.45 260.91,61.45 261.75,62.29 262.61,62.29
INT_SPK_R+ on IN1 (solid shape): 278.98,22.62 280,21.6 280,21.35 279.87,21.22 278.92,21.22 277.96,22.17 277.96,23.12 278.98,23.12
INT_SPK_R+ on IN1 (solid shape): 263.63,61.78 263.63,61.78 263.63,61.68 261.72,61.68 261.62,61.78 261.62,61.89 261.62,61.89 261.62,62.6 261.72,62.7 263.63,62.7
INT_SPK_R- on TOP (solid shape): 280.12,19.44 280.12,18.3 278.85,18.3 278.73,18.43 278.73,18.93 278.47,19.19 278.47,19.57 278.6,19.7 279.87,19.7
INT_SPK_R- on TOP (solid shape): 262.51,61.45 262.51,61.2 262.13,60.82 259.97,60.82 259.92,60.87 259.92,61 259.97,61.05 261.31,61.05 261.8,61.53 262.43,61.53
INT_SPK_R- on IN1 (solid shape): 279.49,20.27 279.49,19.38 279.3,19.19 278.6,19.19 278.41,19.38 278.41,20.65 278.6,20.84 278.92,20.84
INT_SPK_R- on IN1 (solid shape): 263.27,60.49 261.69,60.49 261.47,60.72 261.47,61.4 261.57,61.5 263.27,61.5
INT_SPKR_L+ on TOP (solid shape): 281.52,23.1 281.52,22.31 281.51,22.31 281.39,22.2 280.55,22.2 280.38,22.38 280.38,23.14 280.5,23.26 281.35,23.26
INT_SPKR_L+ on BOTTOM (solid shape): 283.11,22.31 283.08,22.29 281.96,22.29 281.89,22.21 281.13,22.21 281.02,22.31 281.02,23.18 281.15,23.3 283.11,23.3
INT_SPKR_L- on TOP (solid shape): 281.52,25.16 281.52,24.37 281.51,24.37 281.39,24.26 280.55,24.26 280.38,24.43 280.38,25.2 280.5,25.32 281.35,25.32
INT_SPKR_L- on BOTTOM (solid shape): 283.11,25.23 283.11,24.27 283.06,24.22 281.15,24.22 281.02,24.34 281.02,25.13 281.18,25.28 283.06,25.28
INT_SPKR_R+ on TOP (solid shape): 281.52,21.05 281.52,20.27 281.51,20.27 281.39,20.15 280.55,20.15 280.38,20.33 280.38,21.09 280.5,21.22 281.35,21.22
INT_SPKR_R+ on BOTTOM (solid shape): 283.62,21.09 283.62,20.2 283.55,20.14 281.2,20.14 281.01,20.33 281.01,21.16 281.14,21.28 283.42,21.28
INT_SPKR_R- on TOP (solid shape): 281.52,19.02 281.52,18.24 281.51,18.24 281.39,18.12 280.55,18.12 280.38,18.3 280.38,19.06 280.5,19.19 281.35,19.19
INT_SPKR_R- on BOTTOM (solid shape): 283.25,19.28 283.25,18.33 283.03,18.11 281.2,18.11 281.01,18.3 281.01,19.06 281.14,19.19 281.71,19.19 281.9,19.38 283.15,19.38
LG1_ISL88738 on TOP (solid shape): 42.44,71.64 42.44,71.19 42.57,71.07 42.57,70.56 42.44,70.43 41.55,70.43 41.43,70.56 41.43,71.51 41.74,71.83 42.25,71.83
LG1_ISL88738 on TOP (solid shape): 58.98,60.08 58.98,59.65 57.96,58.63 57.89,58.63 57.81,58.71 57.81,59.47 58.55,60.21 58.85,60.21
LG1_ISL88738 on IN3 (solid shape): 59.74,60.36 58.65,59.27 58.27,59.27 58.14,59.4 58.14,59.7 58.72,60.29 58.72,61.07 59.74,61.07
LG1_ISL88738 on IN3 (solid shape): 42.54,71.09 42.54,69.15 42.52,69.12 41.96,69.12 41.36,69.72 41.36,71.07 41.49,71.19 42.44,71.19
LG2_ISL88738 on TOP (solid shape): 60.12,58.76 60.12,58.43 60.02,58.33 59.61,58.33 59.23,57.95 58.16,57.95 58.11,58 58.11,58.1 58.16,58.15 58.95,58.15 59.64,58.84 60.04,58.84
LINE1_L on TOP (solid shape): 254.71,58.99 254.71,58.89 254.66,58.84 253.9,58.84 253.69,58.63 253.69,57.57 252.98,56.86 252.22,56.86 252.22,57.72 253.03,57.72 253.29,57.97 253.29,58.63 253.69,59.04 254.66,59.04
LINE1_R on TOP (solid shape): 254.74,59.4 254.74,59.29 254.66,59.22 253.64,59.22 253.14,58.71 253.14,58.18 253.01,58.05 252.17,58.05 252.17,58.94 252.96,58.94 253.47,59.45 254.68,59.45
LX1_ISL88738 on TOP (solid shape): 45.49,71.26 45.87,70.88 46.51,70.88 47.33,70.05 47.33,67.32 47.14,67.13 43.59,67.13 42.82,67.89 42.82,75.39 45.49,75.39
LX1_ISL88738 on TOP (solid shape): 58.7,60.56 57.63,59.5 57.63,58.68 57.58,58.63 57.48,58.63 57.43,58.68 57.43,59.93 57.81,60.31 57.81,61.5 57.83,61.53 58.7,61.53
LX1_ISL88738 on BOTTOM (solid shape): 47.27,71.96 47.27,66.69 46.57,65.99 42.32,65.99 42.25,66.05 42.25,69.99 42.38,70.11 42.57,70.11 42.7,70.24 42.7,72.53 42.89,72.72 46.51,72.72
LX1_ISL88738 on IN1 (solid shape): 47.32,70.75 46.89,70.75 46.35,70.22 45.52,70.22 45.39,70.34 45.39,71.18 45.97,71.77 47.32,71.77
LX1_ISL88738 on IN1 (solid shape): 58.7,61.83 58.7,60.51 57.86,59.68 57.61,59.68 57.48,59.8 57.48,60.06 57.73,60.31 57.73,61.83 57.81,61.91 58.62,61.91
LX2_ISL88738 on TOP (solid shape): 57.62,69.75 57.62,65.8 56.22,64.4 56.22,62.75 55.21,62.75 55.21,64.4 54.95,64.65 54.95,69.54 55.29,69.89 57.48,69.89
LX2_ISL88738 on TOP (solid shape): 61.11,57.62 60.3,57.62 60.2,57.72 59.66,57.72 59.49,57.54 58.16,57.54 58.11,57.59 58.11,57.69 58.16,57.75 59.23,57.75 59.69,58.2 60.2,58.2 60.48,58.48 61.11,58.48
LX2_ISL88738 on BOTTOM (solid shape): 56.68,69.91 57.17,69.91 57.56,69.53 57.56,65.75 57.38,65.57 54.29,65.57 53.94,65.92 51.52,65.92 51.46,65.99 51.46,70.24 51.71,70.5 56.09,70.5
LX_1.8VALW on BOTTOM (solid shape): 175.41,64.34 175.41,64.21 172.93,61.73 172.49,61.73 172.05,62.18 172.05,62.3 172.44,62.7 172.44,63.38 171.88,63.94 171.88,64.17 172.3,64.59 172.68,64.59 173.19,64.08 173.76,64.08 174.65,64.97 174.78,64.97
LX_1V_PRIM on BOTTOM (solid shape): 155.4,129.47 155.4,129.25 155.35,129.2 155.35,128.79 155.47,128.66 156.31,128.66 156.39,128.59 156.39,127.98 156.31,127.9 155.47,127.9 155.32,127.75 155.32,127.18 154.84,126.69 154.01,126.69 153.95,126.76 153.95,129.42 154.13,129.6 155.27,129.6
LX_1VS_VCCIO on BOTTOM (solid shape): 139.66,131.84 139.66,131.07 139.47,130.88 139.47,130.31 139.6,130.19 140.46,130.19 140.53,130.12 140.53,129.5 140.45,129.42 138.2,129.42 138.07,129.55 138.07,131.96 138.14,132.03 139.47,132.03
LX_3V on BOTTOM (solid shape): 153.34,74.61 153.34,74.48 153.24,74.38 153.24,73.77 153.08,73.62 152.63,73.62 152.25,74 152.25,74.39 152.53,74.67 153.28,74.67
LX_3V on BOTTOM (solid shape): 159.84,73.59 159.35,73.1 159.35,71.32 158.33,71.32 158.33,72.59 158.2,72.72 157.12,72.72 157.12,73.16 157,73.29 156.01,73.29 155.73,73.57 155.73,74.33 155.57,74.48 155.57,75.07 155.64,75.13 157.44,75.13 157.69,75.39 157.69,78.33 157.71,78.34 159.84,78.34
LX_3V on IN1 (solid shape): 153.41,74.48 153.69,74.34 153.98,74.48 154.93,74.48 155.22,74.33 155.51,74.48 157.02,74.48 157.12,74.38 157.12,73.67 157.02,73.57 152.58,73.57 152.25,73.9 152.25,74.38 152.35,74.48
LX_5V on TOP (solid shape): 188.62,53.54 185.73,53.54 185.6,53.57 185.46,53.54 182.84,53.54 182.6,53.78 182.6,54.35 182.8,54.56 183.6,54.56 183.79,54.37 186.33,54.37 187.16,55.19 188.62,55.19
LX_5V on BOTTOM (solid shape): 183.82,54.8 183.82,54.67 183.6,54.46 183.6,54.11 183.48,53.99 182.7,53.99 182.6,54.09 182.6,54.46 183.01,54.86 183.76,54.86
LX_5V on BOTTOM (solid shape): 190.84,56.82 190.84,53.54 188.57,51.27 187.2,51.27 187.13,51.33 187.13,53.06 186.21,53.99 186.21,54.52 186.05,54.67 186.05,55.26 186.12,55.32 187.92,55.32 188.17,55.57 188.17,57.01 190.65,57.01
LX_DDR on TOP (solid shape): 68.48,67.64 68.48,65.86 66.83,65.86 66.83,67.63 66.97,67.77 68.35,67.77
LX_DDR on BOTTOM (solid shape): 68.5,68.63 69.18,67.96 69.18,64.72 69.11,64.65 64.48,64.65 64.1,65.03 64.1,67.61 64.13,67.65 66.27,67.65 67.21,68.59 67.21,70.24 68.5,70.24
Net_55 on BOTTOM (solid shape): 282.2,39.4 278.1,39.4 278.1,47 282.2,47
PBATT+_C on TOP (solid shape): 169.95,58.51 169.95,58.01 170.11,57.85 170.71,57.85 172.1,56.46 174.08,56.46 174.46,56.08 174.46,54.11 174.33,53.99 167.85,53.99 167.09,54.75 167.09,56.97 167.28,57.16 167.92,57.16 168.05,57.29 168.05,58.41 168.39,58.75 169.7,58.75
PBATT+_C on BOTTOM (solid shape): 174.14,58.11 174.14,57.48 172.24,55.57 168.85,55.57 168.05,56.37 168.05,58.94 168.43,59.32 170.08,59.32 171.35,60.59 171.66,60.59
RING2 on TOP (solid shape): 252.14,62.05 252.89,62.05 253.9,61.05 254.66,61.05 254.74,60.97 254.74,60.87 254.68,60.82 253.62,60.82 253.31,61.12 252.5,61.12 252.04,61.58 251.56,61.58 251.56,62.14 252.06,62.14
RING2 on BOTTOM (solid shape): 285.27,46.18 285.27,45.35 285.14,45.22 284.25,45.22 284.12,45.35 284.12,46.18 284.25,46.3 285.14,46.3
RING2 on IN3 (solid shape): 253.19,61.94 254.05,61.94 254.53,61.45 254.53,60.51 253.52,60.51 253.52,60.92 253.31,61.12 252.47,61.12 252.32,61.28 252.32,61.83 252.47,61.99 253.19,61.99
RING2 on IN3 (solid shape): 284.3,46.29 284.48,46.29 284.61,46.16 284.61,45.38 284.48,45.25 283.89,45.25 283.08,46.06 283.08,46.59 283.28,46.8 283.79,46.8
RING2_R on BOTTOM (solid shape): 292.43,46.07 292.43,45.73 292.61,45.56 292.61,45.27 293.58,45.27 293.71,45.14 293.71,43.57 295.74,41.54 295.74,40.71 294.79,40.71 294.47,41.03 294.47,41.22 292.7,43 292.7,44.47 292.58,44.58 292.58,44.6 292.28,44.89 292.27,44.89 292.05,45.11 292.05,45.12 291.45,45.73 291.44,45.73 291.12,46.05 289.2,46.05 288.5,45.35 285.52,45.35 285.52,46.18 285.58,46.24 287.43,46.24 288.25,47.06 291.43,47.06
SA_SNUB on TOP (solid shape): 67.66,115.61 66.64,114.58 66.64,113.68 65.62,113.68 65.62,115.33 66.5,115.33 67,115.83 67,116.55 67.66,116.55
SA_SW on TOP (solid shape): 69.29,115.76 69.29,113.68 68.3,113.68 68.3,115.76 68.45,115.91 69.14,115.91
SA_SW on TOP (solid shape): 63.5,113.47 63.5,113.09 62.89,112.48 62.25,112.48 62.25,113.35 62.86,113.35 63.12,113.6 63.37,113.6
SA_SW on BOTTOM (solid shape): 72.06,116.89 72.06,115.96 71.13,115.96 71.13,115.2 72.06,115.2 72.06,114.03 71.96,113.93 68.73,113.93 68.58,114.08 68.58,114.74 68.45,114.87 65.81,114.87 65.81,115.89 68.73,115.89 69.57,116.72 69.61,116.72 69.95,117.07 71.88,117.07
SLEEVE on TOP (solid shape): 252.42,60.95 253.24,60.95 253.54,60.64 254.68,60.64 254.74,60.59 254.74,60.49 254.66,60.41 252.98,60.41 252.93,60.46 251.66,60.46 251.56,60.56 251.56,61.25 252.12,61.25
SLEEVE on BOTTOM (solid shape): 285.27,44.97 285.27,44.14 285.14,44.02 284.25,44.02 284.12,44.14 284.12,44.97 284.25,45.1 285.14,45.1
SLEEVE on IN3 (solid shape): 253.26,60.82 253.26,59.73 252.25,59.73 252.25,60.79 252.37,60.92 253.16,60.92
SLEEVE on IN3 (solid shape): 284.61,44.94 284.61,44.13 284.5,44.03 283.28,44.03 282.73,44.59 282.73,44.89 282.9,45.07 284.48,45.07
SLEEVE_R on BOTTOM (solid shape): 289.46,44.14 291.36,44.14 291.49,44.02 291.49,43.44 293.52,41.41 293.52,40.97 291.87,40.97 291.81,41.03 291.81,41.41 290.09,43.13 288.44,43.13 287.43,44.14 285.58,44.14 285.52,44.21 285.52,45.03 285.58,45.1 288.5,45.1
SNB_+1VALWP on TOP (solid shape): 160.37,81.53 160.37,80.57 160.27,80.47 157.31,80.47 157.25,80.53 157.25,81.29 157.33,81.37 158.24,81.37 158.51,81.63 160.27,81.63
SNUB_CHG1 on TOP (solid shape): 40.98,69.99 41.36,69.61 41.36,67.83 40.35,67.83 40.35,69.61 40.09,69.86 40.09,70.5 40.98,70.5
SNUB_CHG2 on TOP (solid shape): 52.86,64.65 53.11,64.4 53.55,64.4 53.55,62.75 52.41,62.75 51.97,63.19 51.97,65.42 52.86,65.42
SW_+1VALWP on TOP (solid shape): 160.37,84.19 160.37,82.83 160.28,82.74 159.84,82.74 159.84,82.74 157.15,82.74 157,82.89 157,83.13 157.12,83.26 157.39,83.26 157.44,83.31 157.44,84.25 157.51,84.32 160.25,84.32
SW_+1VALWP on BOTTOM (solid shape): 160.2,84.03 160.2,81.34 160.15,81.29 158.27,81.29 157.06,82.5 156.04,82.5 156.04,83.64 157.14,83.64 157.58,84.08 160.15,84.08
UG1_ISL88738 on TOP (solid shape): 48.6,71.64 48.6,70.24 48.47,70.11 47.59,70.11 47.46,70.24 47.46,71.64 47.65,71.83 48.41,71.83
UG1_ISL88738 on TOP (solid shape): 57.58,60.62 57.58,60.29 57.3,60.01 57.3,59.57 57.22,59.5 57.22,58.68 57.17,58.63 57.07,58.63 57.02,58.68 57.02,59.52 57,59.55 57,59.73 56.84,59.88 56.84,60.36 57.2,60.72 57.48,60.72
UG1_ISL88738 on IN1 (solid shape): 48.56,70.47 48.56,69.38 48.46,69.28 47.62,69.28 47.5,69.4 47.5,70.47 47.62,70.6 48.44,70.6
UG1_ISL88738 on IN1 (solid shape): 57.58,61.25 57.58,60.41 57.3,60.13 57.3,59.88 57.15,59.73 56.79,59.73 56.62,59.9 56.62,61.33 56.92,61.63 57.2,61.63
N16775433 on TOP (solid shape): 68.48,69.86 68.48,68.53 66.95,68.53 66.83,68.65 66.83,70.5 67.84,70.5
N16775517 on BOTTOM (solid shape): 66.67,68.91 66.67,68.57 66.06,67.96 64.1,67.96 64.1,68.83 64.11,68.84 64.72,68.84 64.86,68.71 65.86,68.71 66.13,68.97 66.61,68.97
N16783014 on TOP (solid shape): 157.99,80 157.99,78.03 156.62,76.66 155.85,76.66 155.73,76.78 155.73,77.8 156.11,78.18 156.11,79.46 156.69,79.46 156.95,79.21 157.38,79.21 157.5,79.34 157.5,80.02 157.96,80.02
N16783014 on BOTTOM (solid shape): 156.68,77.48 156.68,76.08 156.36,75.77 155.66,75.77 155.54,75.89 155.54,76.4 155.73,76.59 155.73,77.54 155.85,77.67 156.49,77.67
N16783223 on BOTTOM (solid shape): 187.14,57.17 187.14,56.22 186.89,55.97 186.1,55.97 186.05,56.02 186.05,56.6 186.33,56.88 186.33,57.16 186.52,57.35 186.96,57.35
N16784595 on BOTTOM (solid shape): 158.01,71.32 157.47,71.32 156.97,70.83 155.93,70.83 155.93,71.44 156.82,71.44 157.12,71.74 157.12,71.96 158.01,71.96
N16784799 on BOTTOM (solid shape): 188.06,50.52 188.06,49.91 185.95,49.91 185.95,50.54 188.03,50.54
N17370862 on BOTTOM (solid shape): 46,112.28 46,111.64 45.68,111.33 45.68,109.55 45.62,109.48 44.16,109.48 44.09,109.55 44.09,109.99 44.16,110.06 44.79,110.06 45.05,110.31 45.05,111.77 45.68,112.41 45.87,112.41
N17371029 on BOTTOM (solid shape): 48.67,121.23 48.64,121.21 48.61,121.18 48.49,120.88 48.67,120.61 48.67,119.24 47.83,118.4 47.62,118.4 47.52,118.5 47.52,119.21 47.7,119.39 47.7,120.8 47.27,121.23 47.27,121.87 48.67,121.87
N17802718 on TOP (solid shape): 48.89,103.36 48.89,102.66 48.09,101.86 44.7,101.86 44.58,101.99 44.58,102.55 44.6,102.55 44.6,102.56 47.4,102.56 48.3,103.47 48.78,103.47
N18278782 on TOP (solid shape): 58.67,62.32 56.62,62.32 56.62,62.95 58.67,62.95
N39469998 on TOP (solid shape): 61.49,112.48 61.47,112.46 59.79,112.46 59.64,112.61 59.64,113.22 59.79,113.37 61.49,113.37
N39473185 on BOTTOM (solid shape): 60.59,91.04 60.59,89.83 60.26,89.5 59.9,89.5 59.78,89.37 59.78,88.73 58.89,88.73 58.89,89.37 59.35,89.83 60.06,89.83 60.39,90.16 60.39,91.04 60.44,91.1 60.54,91.1
N39473187 on BOTTOM (solid shape): 61,91.06 61,88.72 60.11,88.72 60.11,89.36 60.39,89.36 60.78,89.75 60.78,91.04 60.83,91.1 60.96,91.1
N39473189 on BOTTOM (solid shape): 60.98,87.34 58.9,87.34 58.9,87.97 60.98,87.97
N39473270 on BOTTOM (solid shape): 54.13,110.96 54.13,110.55 54.66,110.02 55.5,110.02 55.55,109.97 55.55,109.87 55.5,109.82 54.2,109.82 53.82,110.2 53.31,110.2 53.29,110.22 53.29,111.09 54,111.09
N39473272 on BOTTOM (solid shape): 54.18,109.64 55.5,109.64 55.55,109.59 55.55,109.46 55.5,109.41 54.58,109.41 54.15,108.98 53.31,108.98 53.31,109.87 53.95,109.87
N39473274 on BOTTOM (solid shape): 52.55,108.98 51.89,108.98 51.89,111.09 52.55,111.09
N132000604 on TOP (solid shape): 62.51,56.4 61.87,56.4 61.87,58.51 62.51,58.51

Small or netless copper shapes (teardrops, artwork): 309 on TOP, 74 on BOTTOM, 4 on GND1, 4 on GND2

## Text on the board
Ref Des/Silkscreen Bottom: REV:A00 | PWA P/N: | ALL RIGHT RESERVED | PWB TP1NV | COPYRIGHT 2016 | H25 | 9 | M2X3 | H26 | 10 | 11 | FAN CABLE | SPEAKER | EDP CABLE | DIMM | DDR4 | CABLE | BATTERY | TP | USH | RTC | LED | DC-IN | 2 | 3 | 4 | 5 | 6 | 1 | 7 | 8 | WLAN | WIGIG | BT | WWAN
User.Comments: LA-E121P | 2016-11-08 | 2017-11-08 | CAZ10 | Minjia | GND | +VCC_GT | +VCC_SA | +VCC_CORE | +3.3V_ALW | +3.3V_RUN | +1.0VS_VCCIO | +3.3V_ALW_PCH | +1.0V_PRIM | +5V_ALW | +5V_RUN | GNDA
BODY_CENTER: L7 | L8 | TOP | GND1 | IN1 | VCC | IN2 | IN3 | GND2 | BOT
User.40: L5/L7
User.41: FIGURE | SIZE | 8.0 | 16.0 | 20.0 | 22.0 | 28.0 | 35.0 | 39.0 | 102.0 | 122.0 | 126.0 | 134.0 | 138.0 | 150.0 | 30.0 | 31.0 | 43.0 | 45.0 | 63.0 | 65.0 | 71.0 | 91.0 | 47.0x16.0 | 55.0x24.0 | 55.0x28.0 | 57.0x24.0 | 63.0x24.0 | 63.0x31.0 | 67.0x28.0 | 94.0x28.0 | 94.0x43.0 | 37.0x28.0 | 106.0x91.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 5592 | 12 | 33 | 19 | 18 | 10 | 5 | 2 | 4 | 1 | 3 | 7
