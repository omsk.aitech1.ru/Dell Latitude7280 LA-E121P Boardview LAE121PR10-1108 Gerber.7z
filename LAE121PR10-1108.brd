# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_PWRBTN#: length 316.7
  TOP w0.112: UE1.K11 v2(254.28,92.26) ; v2(91.51,128.79) 91.35,128.63 CC269.1 RC241.1 91.35,127.05 88.82,124.52 88.82,120.15 87.3,118.63 82.7,118.63 81.1,117.02 79.54,117.02 78.51,115.99 v2(78.51,115.63)
  IN1 w0.119: v2(128.29,83.58) 122.22,77.5 88.39,77.5 79.49,86.4 75.62,86.4 v2(75.14,85.93)
  IN2 w0.124: v2(142.65,78.57) 142.98,78.57 144.02,77.53 144.02,74.42 146.18,72.26 146.18,71.72 149.17,68.72 149.66,68.72 150.04,68.33 158.68,68.33 162.2,64.81 170.42,64.81 173.87,61.36 181.87,61.36 182.17,61.07 201.53,61.07 203.67,58.93 205.76,58.93 206.39,58.3 207.27,58.3 207.92,57.65 215.56,57.65 216.64,58.73 218.54,58.73 219.1,58.16 225.61,58.16 226.42,57.35 235.43,57.35 236.63,58.55 242.35,58.55 243.68,59.89 243.68,60.84 246.01,63.17 246.01,64.49 247.55,66.03 251.08,66.03 251.87,66.81 251.87,67.32 252.3,67.75 258.21,67.75 259.82,69.36 259.82,70.08 260.14,70.39 260.27,70.39 264.54,74.66 264.54,81.52 263.45,82.61 263.45,83.44 262.92,83.96 262.92,86.68 261.95,87.66 261.95,91.58 261.22,92.31 260.02,92.31 258.27,94.07 254.61,94.07 254.18,93.64 253.21,93.64 253.09,93.51 253.09,92.85 253.28,92.66 253.66,92.66 254.06,92.26 v2(254.28,92.26)
  BOTTOM w0.076: 126.54,86.6 125.57,87.56 125.39,87.56 123.6,89.36 123.6,91.07 UC1.BA15
  BOTTOM w0.112: v2(75.14,85.93) 75.14,87.6 76.57,89.03 76.57,92.64 78.2,94.26 v1(78.2,114.54) 78.2,115.32 v2(78.51,115.63) ; v2(142.65,78.57) 143.08,78.99 143.08,79.39 142.51,79.96 136.71,79.96 135.76,79 131.24,79 128.29,81.95 v2(128.29,83.58) 128.29,84.14 126.54,85.89 126.54,86.6 ; JXDP1.41 v2(91.51,128.79)
SIO_RCIN#: length 183
  TOP w0.112: RE339.1 v2(261.47,83.17) ; RC13.1 135.99,81.28 135.6,81.67 v2(135.6,82.43)
  IN2 w0.124: v2(259.87,70.7) 259.08,69.91 256.23,69.91 255.9,70.24 254.63,70.24 254.42,70.03 254.42,69.75 254.23,69.56 251.1,69.56 249.6,68.06 248.11,68.06 245.11,65.05 245.11,63.59 242.78,61.25 242.78,60.26 241.97,59.46 236.25,59.46 235.06,58.26 228.8,58.26 227.23,59.83 226.56,59.83 225.68,60.71 219.34,60.71 218.37,59.75 216.38,59.75 215.19,58.55 208.31,58.55 207.67,59.2 206.77,59.2 206.14,59.83 204.04,59.83 201.9,61.97 182.54,61.97 182.25,62.27 181.1,62.27 180.24,63.13 178.97,63.13 178.43,62.6 173.92,62.6 170.8,65.72 162.74,65.72 159.22,69.24 150.61,69.24 150.16,69.68 149.86,69.68 147.47,72.07 147.47,79.84 143.02,84.29 136.66,84.29 135.6,83.22 v2(135.6,82.43)
  BOTTOM w0.076: UC1.AW13 125.1,92.54 124.92,92.36 124.92,92.36 124.7,91.66 124.7,91.58 124.65,91.42 124.65,91.28 124.71,91.06 124.71,90.94 124.67,90.85 124.66,90.83 124.66,90.45 124.79,90.32 124.79,89.78 v4(126.62,87.95) 127.07,87.49
  BOTTOM w0.112: v2(261.47,83.17) 260.94,82.64 260.94,78.95 260.69,78.7 260.69,76.55 260.88,76.36 260.88,74.73 259.89,73.74 259.89,70.73 v2(259.87,70.7) ; 127.07,87.49 127.23,87.49 130.3,84.42 132.98,84.42 133.92,83.48 134.56,83.48 v2(135.6,82.43)
SIO_RCIN#_EC: length 4.5
  TOP w0.112: RE339.2 258.94,83.17 v1(258.39,83.72) 256.98,85.13 256.88,85.13 256.55,85.46 UE1.N3
SIO_SLP_A#: length 225.6
  TOP w0.107: UE1.M11 255.92,91.43 256.99,91.43 258.93,93.37 258.93,94.74 v2(259.56,95.36)
  TOP w0.112: v2(256.74,102.16) 256.74,102.23 259.61,105.1 v1(259.61,105.14) 260.45,105.14 262.06,106.75 JAPS1.6
  IN1 w0.119: v2(259.56,95.36) 260.42,96.22 260.42,102.31 259.74,102.98 257.12,102.98 256.74,102.6 v2(256.74,102.16)
  IN2 w0.076: 123.12,95.69 123.33,95.48 123.33,95.09 123.26,95.02 123.26,93.86 123.53,93.6 123.84,93.6 125.2,92.24 125.69,92.24
  IN2 w0.124: v2(259.28,70.7) 258.97,71.02 256.33,71.02 256.01,70.69 253.28,70.69 253.02,70.44 250.56,70.44 249.12,69 247.61,69 247.36,69.25 245.91,69.25 245.57,68.91 245.2,68.91 244.98,68.69 244.98,67.7 243.89,66.61 243.89,64.86 242.47,63.44 241.72,63.44 241.03,62.75 238.02,62.75 237.41,62.14 237.32,62.14 236.68,61.5 234.96,61.5 234.82,61.36 226.95,61.36 226.24,62.07 218.77,62.07 217.96,61.25 204.76,61.25 202.56,63.45 184.64,63.45 182.64,65.45 176.05,65.45 175.63,65.04 175.02,65.04 172.97,67.09 163.65,67.09 160.15,70.59 151.36,70.59 150.82,71.13 150.49,71.13 148.92,72.71 148.92,80.38 145.59,83.71 145.59,85.33 144.25,86.67 136.98,86.67 132.19,81.88 129.53,81.88 129.29,82.12 129.29,83.45 126.63,86.1 126.63,91.3 125.69,92.24 ; v2(122.9,95.92) 123.12,95.69
  BOTTOM w0.102: UC1.AN16 123.35,96.35 v2(122.9,95.92)
  BOTTOM w0.112: v2(259.28,70.7) 259.68,71.1 259.68,76 260.13,76.44 260.13,78.84 260.38,79.1 260.38,85.05 260.27,85.16 260.27,86.23 259.28,87.22 259.28,95.08 v2(259.56,95.36)
SIO_SLP_LAN#: length 218.5
  TOP w0.107: UE1.H9 v2(252.68,90.66)
  TOP w0.112: UZ2.5 252.77,111.6 v2(253.2,112.02) ; v2(143.03,81.99) 142.35,81.99 142.18,82.17 RC344.1 141.57,81.74 141.62,81.68 RC68.1
  IN2 w0.124: v2(143.03,81.99) 143.2,81.99 143.64,81.56 143.64,79.69 143.33,79.39 143.33,78.93 144.78,77.48 144.78,74.34 146.86,72.25 146.86,71.92 149.58,69.2 149.92,69.2 150.33,68.79 158.96,68.79 162.48,65.27 170.61,65.27 174.06,61.82 182.06,61.82 182.36,61.52 201.71,61.52 203.85,59.38 205.95,59.38 206.58,58.75 207.46,58.75 208.11,58.1 215.37,58.1 216.48,59.2 218.77,59.2 219.29,58.69 219.48,58.69 219.58,58.79 227.64,58.79 228.62,57.81 235.24,57.81 236.44,59 242.16,59 243.23,60.07 243.23,61.05 245.56,63.38 245.56,64.8 247.72,66.97 249.2,66.97 251.31,69.07 257.33,69.07 v2(257.73,69.48)
  IN3 w0.135: v2(253.2,112.02) 253.85,111.37 253.85,108.02 252.12,106.28 252.12,99.24 251.04,98.16 251.04,95.27 253.08,93.23 253.08,91.05 v2(252.68,90.66)
  BOTTOM w0.076: 126.76,87.21 126.07,87.89 125.53,87.89 125.21,88.21 125.21,88.26 v4(124.85,88.62) 123.98,89.5 123.98,90.37 124.14,90.53 124.14,92 123.98,92.34 123.98,92.33 123.82,92.49 UC1.AW15
  BOTTOM w0.112: v2(257.73,69.48) 258.14,69.89 258.14,72.68 257.88,72.93 257.88,74.46 258.14,74.71 258.14,76.77 257.38,77.53 257.38,78.76 258.25,79.63 258.25,80.96 258.71,81.42 258.71,84.52 257.69,85.54 257.69,86.18 256.79,87.07 256.79,90.45 255.39,91.85 253.22,91.85 253.08,91.71 253.08,91.05 v2(252.68,90.66) ; 126.76,87.21 127.1,87.21 130.12,84.19 132.83,84.19 133.91,83.1 134.16,83.1 135.58,81.67 137.57,81.67 138.26,82.37 142.24,82.37 142.62,81.99 v2(143.03,81.99)
SIO_SLP_S0#: length 298.8
  TOP w0.112: PR426.1 v2(165.25,128.41) 165.51,128.15 165.51,124.36 162.95,121.81 v2(162.95,120.09) 165.07,117.97 165.07,115.78 163.68,114.39 163.68,110.37 168.71,105.34 168.71,99.27 arc(170.03,90.66) 173.81,82.81 arc(175.04,81.21) 176.33,79.64 arc(180.35,75.78) 185.09,72.83 arc(190.13,71.05) 195.45,70.45 209.09,70.45 209.93,71.28 v2(209.93,71.59) ; PR425.1 v2(139.71,128.03) ; JAPS1.15 257.56,103.87 255.49,101.79 v2(255.49,101.55)
  IN1 w0.119: v2(123.62,130.77) 124.3,131.46 126.2,131.46 127.15,130.5 127.79,130.5 130.28,128.01 139.71,128.01 v2(139.71,128.03) 140.27,128.59 143.24,128.59 144.65,130 148.09,130 149.02,130.92 156.4,130.92 158.65,133.17 160.49,133.17 v2(165.25,128.41)
  IN2 w0.124: v2(125.7,94.09) 126.07,94.46 128.7,94.46 129.15,94.02 136.07,94.02 137.82,95.77 137.82,97.1 138.96,98.25 138.96,100.37 140,101.41 142.04,103.45 142.04,107.59 138.61,111.01 138.61,111.86 137.67,112.8 137.67,116.89 139.77,118.99 139.77,121.84 138.9,122.71 138.9,124.26 139.65,125.01 139.65,127.97 v2(139.71,128.03) ; v2(209.93,71.59) 210.36,72.02 210.97,72.02 211.29,72.34 216.24,72.34 217.83,73.92 222.91,73.92 224.62,75.64 224.62,78.75 225.18,79.31 231,79.31 231.76,78.55 232.79,78.55 232.98,78.74 232.98,90 234,91.02 237.29,91.02 242.26,96 242.47,96 244.66,98.19 249.9,98.19 250.26,98.56 254.21,98.56 255.23,99.58 255.23,101.29 v2(255.49,101.55)
  BOTTOM w0.112: RZ363.1 158.05,115.95 158.05,116.34 158.82,117.12 161.38,117.12 162.95,118.69 v2(162.95,120.09) 161.65,121.39 154.37,121.39 153.4,120.43 153.4,118.27 154.23,117.44 154.23,113.22 153.63,112.62 153.63,110.83 RZ112.1 ; UZ35.1 v2(123.62,130.77)
  BOTTOM w0.254: v2(125.7,94.09) 125.71,94.09 126.07,94.45 UC1.AT11
SIO_SLP_S3#: length 441.1
  TOP w0.076: 25.54,94.88 25.54,95.11 25.86,95.42 25.86,96.3 25.93,96.37 25.93,96.77 UT1.D2
  TOP w0.107: UE1.K9 v2(254.28,90.66)
  TOP w0.112: JAPS1.2 264.06,107.33 v1(263.12,106.38) 261.01,104.28 260.39,104.28 259.94,103.83 259.94,102.65 260.55,102.04 QE11.2 261.52,102.04 261.92,101.64 261.92,99.97 v2(262.16,99.73) RE280.1 262.28,98.96 UE5.1 263.92,98.96 264.63,98.25 UE3.2 ; 25.54,94.88 25.54,94.42 25.23,94.12 v2(25.23,93.67)
  IN1 w0.119: v2(123.34,134.5) 122.96,134.12 122.96,128.84 124.29,127.51 129.63,127.51 130.38,126.76 133.27,126.76 134.63,125.4 137.05,125.4 v2(137.5,125.85)
  IN2 w0.076: 125.96,92.5 125.21,92.5 123.94,93.77 123.66,93.77 123.45,93.97 123.45,94.98 v2(123.81,95.34) 124.17,95.69 127.43,95.69 127.47,95.65 127.78,95.65
  IN2 w0.124: v2(123.34,134.5) 122.91,134.07 122.53,134.07 121.51,135.09 90.21,135.09 88.33,133.21 83.7,133.21 79.24,128.75 75.83,128.75 75.54,129.04 67.11,129.04 66.8,128.74 62.3,128.74 61.37,127.81 47.13,127.81 45.97,126.66 40.66,126.66 40.33,126.33 36.96,126.33 34.75,124.12 31.29,124.12 30.28,123.1 30.28,112.33 30.63,111.97 30.63,109.59 31.01,109.21 32.69,109.21 35.91,105.98 35.91,101.59 36.42,101.08 36.42,95.62 35.71,94.91 34.24,94.91 32.56,96.58 27.2,96.58 26.64,96.02 26.64,95.08 v2(25.23,93.67) ; v2(258.06,93.36) 259.33,92.09 261.12,92.09 261.72,91.49 261.72,87.55 262.69,86.58 262.69,83.87 263.21,83.36 263.21,82.49 264.31,81.38 264.31,74.76 260.82,71.26 256.25,71.26 255.91,70.92 253.18,70.92 252.93,70.67 250.44,70.67 248.99,69.23 247.7,69.23 247.42,69.51 245.84,69.51 245.47,69.14 244.6,69.14 243.41,67.95 243.41,65.02 242.41,64.02 241.66,64.02 240.91,63.27 237.8,63.27 237.11,62.57 218.64,62.57 217.89,61.83 204.89,61.83 202.8,63.92 184.82,63.92 182.83,65.91 176.12,65.91 174.45,67.57 163.93,67.57 160.46,71.05 151.57,71.05 149.6,73.01 149.6,80.34 146.08,83.86 146.08,86.55 144.82,87.81 130.65,87.81 125.96,92.5 ; v2(137.5,125.85) 137.5,122.75 138.87,121.38 138.87,119.86 136.75,117.74 136.75,112.44 137.71,111.48 137.71,110.19 139.86,108.05 139.86,106.15 140.36,105.64 140.36,104.51 138.97,103.12 138.97,102.26 138.21,101.5 138.21,98.64 137.06,97.48 137.06,96.15 136.19,95.29 131.48,95.29 130.22,96.54 129.21,96.54 128.83,96.16 128.83,95.86 128.62,95.65 127.78,95.65
  IN3 w0.135: v2(262.16,99.73) 262.15,99.73 262.15,99.36 259.03,96.24 259.03,94.32 v2(258.06,93.36) 255.76,91.06 254.68,91.06 v2(254.28,90.66)
  BOTTOM w0.076: UC1.AP15 124.27,95.72 v2(123.81,95.34)
SIO_SLP_S4#: length 502.1
  TOP w0.107: v2(258.15,94.5) 257.45,93.8 257.45,92.95 257.16,92.66 UE1.N12
  TOP w0.112: UZ34.2 v1(139.79,71.26) 139.79,71.84 v2(139.22,72.4) ; v2(257.32,102.15) 257.32,102.25 259.86,104.79 260.55,104.79 262.56,106.79 JAPS1.5 ; PR513.1 148.41,57.49 v2(148.17,57.73) ; PR208.1 70.9,73.43 v2(70.7,73.23) ; v2(39.39,109.13) 39.55,109.28 39.55,111.42 39.88,111.75 40.49,111.75 46.82,118.08 46.82,125.09 47.6,125.87 48.22,125.87 48.98,125.11 49.68,125.11 50.19,125.61 v2(50.19,125.93) ; UZ21.4 125.93,128.49 125.45,128.96 v2(125.45,130.79)
  IN1 w0.119: v2(37.84,78.57) 38.25,78.98 42.57,78.98 44.5,77.05 57,77.05 57.7,77.75 69.04,77.75 70.56,76.24 70.56,73.37 v2(70.7,73.23) 71.27,73.8 80.69,73.8 87.06,67.43 142.72,67.43 143.64,66.51 v2(143.66,66.51) ; v2(258.15,94.5) 258.75,95.1 258.75,97.32 258.93,97.5 258.93,99.32 257.32,100.93 v2(257.32,102.15)
  IN2 w0.124: v2(148.17,57.73) 148.17,58.43 147.08,59.52 145.46,59.52 144.07,60.92 144.07,64.58 143.66,64.98 v2(143.66,66.51) 143.13,67.04 143.13,68.13 139.22,72.04 v2(139.22,72.4) ; v2(141.63,78.6) 141.81,78.6 142.26,78.14 143.05,78.14 143.74,77.46 143.74,74.38 145.82,72.3 145.82,71.64 148.97,68.49 149.43,68.49 149.81,68.11 158.57,68.11 162.09,64.59 170.33,64.59 173.78,61.14 181.78,61.14 182.08,60.84 201.43,60.84 203.57,58.7 203.92,58.7 205.26,57.36 215.6,57.36 216.71,58.48 218.44,58.48 218.99,57.92 225.44,57.92 226.31,57.05 226.31,56.54 226.66,56.2 229.84,56.2 230.56,55.48 232.99,55.48 233.24,55.73 234.13,55.73 236.72,58.33 242.44,58.33 243.91,59.79 243.91,60.71 248.99,65.8 251.2,65.8 252.09,66.69 252.09,67.17 252.45,67.52 258.34,67.52 259.67,68.85 260.41,68.85 260.73,69.16 260.73,70.52 264.77,74.56 264.77,81.64 264.09,82.31 264.09,85.83 262.17,87.75 262.17,91.68 261.31,92.54 260.31,92.54 258.35,94.5 v2(258.15,94.5) ; v2(50.19,125.93) 50.61,126.35 61.94,126.35 62.62,127.04 67.49,127.04 68.05,127.6 74.88,127.6 75.14,127.34 79.75,127.34 83.28,130.87 103.64,130.87 104.38,131.61 108.9,131.61 108.99,131.52 117.61,131.52 118.08,131.99 124.25,131.99 v2(125.45,130.79) ; v2(39.39,109.13) 40.21,109.13 41.02,108.32 41.02,103.54 42.21,102.35 42.21,99.1 41.05,97.93 41.05,87.41 38.89,85.25 38.89,80.88 37.84,79.84 v2(37.84,78.57)
  IN3 w0.135: v2(139.22,72.4) 135.56,76.07 v2(135.56,78.27)
  BOTTOM w0.076: UC1.BA16 123.27,91.63 123.27,89.19 125.18,87.28 125.18,87.13
  BOTTOM w0.112: v2(141.63,78.6) 141.56,78.67 139.01,78.67 138.78,78.45 137.97,78.45 137.44,78.98 136.42,78.98 135.71,78.27 v2(135.56,78.27) 131.15,78.27 127.47,81.95 127.47,84.12 126.01,85.58 126.01,86.31 125.18,87.13
SIO_SLP_S5#: length 215.6
  TOP w0.107: UE1.N8 257.2,89.46 257.26,89.39 v2(257.4,89.39)
  TOP w0.112: v2(257.91,102.15) 257.91,102.53 259.91,104.53 260.78,104.53 263.06,106.81 JAPS1.4
  IN2 w0.124: v2(259.76,68.24) 258.79,67.27 255.07,67.27 254.51,66.71 252.45,66.71 251.3,65.56 249.09,65.56 244.14,60.62 244.14,59.71 242.53,58.1 236.81,58.1 234.22,55.51 233.37,55.51 233.09,55.23 230.49,55.23 229.75,55.97 226.56,55.97 226.05,56.49 226.05,56.92 225.3,57.67 218.89,57.67 218.33,58.22 216.78,58.22 214.93,56.37 207.51,56.37 207,56.88 203.84,56.88 200.1,60.62 181.98,60.62 181.69,60.91 173.69,60.91 170.24,64.36 161.99,64.36 158.47,67.88 149.65,67.88 149.27,68.26 148.84,68.26 145.54,71.56 145.54,72.26 143.51,74.29 143.51,77.35 142.98,77.89 141.98,77.89 141.86,78.01 v2(141.63,78.01)
  BOTTOM w0.076: 124.93,87.07 124.93,87.28 123.11,89.1 123.11,91.23 122.94,91.39 122.94,91.82 123.24,92.12 UC1.AY16
  BOTTOM w0.112: v2(257.91,102.15) 257.91,100.45 258.01,100.34 258.01,99.22 257.44,98.65 256.16,98.65 255.48,97.97 255.48,94.64 256.2,93.92 256.2,91.64 257.4,90.44 v2(257.4,89.39) 257.98,88.82 258.1,88.82 258.78,88.14 258.78,87.13 259.84,86.06 259.84,84.98 259.96,84.87 259.96,79.28 259.64,78.96 259.64,77.48 259.1,76.94 259.1,76.26 259.25,76.11 259.25,71.89 258.65,71.28 258.65,69.77 259.76,68.66 v2(259.76,68.24) ; 124.93,87.07 124.93,87.01 125.75,86.18 125.75,84.59 127.15,83.2 127.15,80.94 130.37,77.73 138.37,77.73 139.1,78.46 141.18,78.46 v2(141.63,78.01)
SIO_SLP_SUS#: length 278.6
  TOP w0.112: RE349.1 263.4,83.2 264.77,81.83 264.77,77.71 263.78,76.72 262.74,76.72 262.23,77.23 v2(261.58,77.23) ; v2(155.47,103.63) 155.08,104.03 155.08,104.67 153.31,106.44 153.31,107.64 153.62,107.95 153.62,113.17 154.27,113.82 154.27,117.84 v1(155.5,119.07) 160.67,124.25 164.69,124.25 165.17,124.74 165.17,126.97 PR406.1 ; RZ64.1 159.84,61.12 v2(159.84,61.61) ; UZ34.1 140.44,69.4 140.68,69.16 142.22,69.16 146.35,65.03 147.62,65.03 v2(147.85,64.81) ; v2(175.32,68.3) 174.66,68.3 174.12,67.76 174.12,64.38 169.47,59.73 168.18,59.73 167.79,59.35 166.67,59.35 166.34,59.68 v2(164.59,59.68) ; v2(136.52,91.62) 136.52,90.54 137.37,89.69 137.37,88.31 137.64,88.05 139.01,88.05 139.86,87.2 141.55,87.2 141.88,86.87 143.82,86.87 144.23,87.28 147.38,87.28 v2(147.78,86.88) 147.97,86.68 151.45,86.68 153.77,89 156.32,89 v2(157.01,88.31) 157.62,88.92 160.88,88.92 v2(161.59,89.63)
  IN1 w0.119: v2(159.84,61.61) 161.77,59.68 v2(164.59,59.68)
  IN2 w0.124: v2(175.32,68.3) 176.81,66.81 183.2,66.81 185.16,64.86 203.14,64.86 204.49,63.51 227.22,63.51 228.77,65.06 229.42,65.06 230.12,64.36 236.34,64.36 237.54,65.55 240.1,65.55 241.12,66.57 241.12,67.37 242.92,69.18 243.56,69.18 244.2,69.82 245.19,69.82 245.87,70.5 249.29,70.5 249.91,71.12 252.74,71.12 252.99,71.37 255.72,71.37 256.12,71.77 260.14,71.77 v2(260.28,71.9) ; v2(147.85,64.81) 147.92,64.87 148.99,64.87 149.4,64.46 157.58,64.46 159.84,62.2 v2(159.84,61.61)
  IN3 w0.135: v2(161.59,89.63) 161.59,90.04 161.01,90.61 161.01,102.96 160.62,103.35 159.27,103.35 159.17,103.44 155.66,103.44 v2(155.47,103.63) ; v2(123.82,96.1) 124.12,96.1 125.37,94.84 126.92,94.84 127.31,94.46 127.68,94.46 127.96,94.17 127.96,92.74 129.44,91.26 136.16,91.26 v2(136.52,91.62) ; v2(147.78,86.88) 147.78,85.69 146.69,84.6 146.69,80.42 145.68,79.4 145.68,71.61 148.13,69.15 148.13,65.75 147.85,65.47 v2(147.85,64.81)
  BOTTOM w0.102: UC1.AN15 123.96,96.1 v2(123.82,96.1)
  BOTTOM w0.112: v2(260.28,71.9) 260.11,72.08 260.11,73.44 261.58,74.92 v2(261.58,77.23) ; v2(175.32,68.3) 174.66,68.3 PR504.1 ; PR312.2 157,88.3 v2(157.01,88.31)
SIO_SLP_WLAN#: length 217
  TOP w0.112: v2(219.78,70.96) 220.66,70.07 225.63,70.07 226.26,70.7 227.51,70.7 227.88,71.07 227.88,73.49 229.05,74.66 229.05,82.43 231.82,85.2 v2(232.1,85.2) ; v2(249.12,103.9) 249.12,104.34 251.74,106.96 RZ71.1 ; UE1.D9 v2(248.68,90.66)
  IN1 w0.119: v2(248.68,90.66) UE1.D9 249.66,90.26 249.87,90.48 249.87,92.53 249.67,92.73 249.67,96.33 248.38,97.62 248.38,103.15 v2(249.12,103.9)
  IN2 w0.124: v2(249.12,103.9) 248.74,104.28 244.31,104.28 242.34,106.25 237.45,106.25 237.01,105.8 234.28,105.8 233.2,104.72 233.2,103.3 230.48,100.58 230.48,86.83 v2(232.1,85.2) ; v2(141.04,77.99) 140.84,77.79 140.84,76.69 142.65,74.89 142.65,74.19 144.78,72.06 144.78,71.23 148.51,67.5 149.05,67.5 149.34,67.2 158.03,67.2 161.55,63.68 167.97,63.68 171.43,60.23 181.41,60.23 181.7,59.94 199.82,59.94 203.63,56.13 206.45,56.13 208.02,54.56 212.52,54.56 213.29,55.33 217.07,55.33 v2(218.46,56.73)
  BOTTOM w0.076: UC1.BB17 122.78,90.58 122.78,88.87 124.36,87.29 124.36,87.13
  BOTTOM w0.112: 124.36,87.13 124.36,86.31 124.67,85.99 125.25,85.99 125.5,85.74 125.5,84.47 126.87,83.09 126.87,80.87 130.25,77.49 140.55,77.49 v2(141.04,77.99) ; v2(219.78,70.96) 219.91,70.82 219.91,70.07 218.67,68.83 218.67,56.93 v2(218.46,56.73)
SLEEVE: length 43.2
  IN3 w1.016: 283.16,44.87 272.49,55.54 268.71,55.54 264.81,51.64 259.04,51.64 256.37,54.3 254.02,54.3 252.56,55.76 252.56,58.43 252.75,58.62 252.75,59.89
  BOTTOM w0.127: v2(284.38,44.27) v1(283.7,44.27)
  vias: v2(252.58,60.69) v2(253.16,60.67) v2(284.38,44.84)
SLEEVE_R: length 2.9
  BOTTOM w0.102: 285.65,44.14 285.65,43.89 284.69,42.94 v1(283.42,42.94)
SLOT2_CONFIG_0: length 51.3
  TOP w0.107: UE1.N9 256.88,90.26 258.82,92.2 ; RPE9.4 261.34,93.24 v2(260.87,93.71)
  TOP w0.112: v1(234.78,108.71) 235.18,108.32 v2(235.49,108.32) ; v2(260.87,93.71) 259.36,92.2 258.82,92.2
  IN2 w0.124: v2(260.87,93.71) 261.21,93.71 261.75,94.24 261.75,95.85 261.54,96.05 261.54,98.74 260.99,99.29 260.99,99.87 261.23,100.1 261.23,100.67 260.76,101.14 260.76,102.31 258.53,104.54 256.04,104.54 255.53,105.05 244.74,105.05 242.61,107.19 238.01,107.19 236.88,108.32 v2(235.49,108.32)
  BOTTOM w0.112: JNGFF2.13 231.03,106.75 232.6,108.32 v2(235.49,108.32)
SLOT2_CONFIG_1: length 48.5
  TOP w0.107: v2(260.86,94.3) 261,94.3 261.55,93.74 RPE9.3 ; UE1.M10 255.88,90.66 256.82,90.66 258.74,92.58
  TOP w0.112: 258.74,92.58 v1(259.12,92.58) 259.14,92.58 v2(260.86,94.3)
  IN2 w0.124: v2(260.86,94.3) 260.42,94.3 259.96,94.77 259.96,97.2 260.18,97.43 260.18,98.75 259.13,99.81 257.82,99.81 254.66,102.97 243.1,102.97 239.32,99.19 235.96,99.19 v2(234.21,97.43)
  BOTTOM w0.112: JNGFF2.61 231.86,94.75 234.21,97.1 v2(234.21,97.43)
SLOT2_CONFIG_2: length 49.5
  TOP w0.107: v2(260.86,94.88) 261.5,94.24 RPE9.2 ; UE1.N10 256.92,91.06 v1(259.68,93.81)
  TOP w0.112: v1(259.68,93.81) 260.74,94.88 v2(260.86,94.88)
  IN2 w0.124: v2(260.86,94.88) 260.53,94.88 260.22,95.18 260.22,97.06 260.48,97.32 260.48,98.94 259.36,100.06 257.89,100.06 254.7,103.25 243.06,103.25 239.99,100.17 239.96,100.17 239.25,99.46 235.61,99.46 v2(234.21,98.07)
  BOTTOM w0.112: JNGFF2.67 231.41,93.25 231.85,93.69 231.85,94.33 234.59,97.07 234.59,97.68 v2(234.21,98.07)
SLOT2_CONFIG_3: length 78.7
  TOP w0.112: UE1.F4 v2(250.28,85.86) ; RPE9.1 261.57,94.74 v2(260.84,95.46) 260.58,95.46 v1(260.2,95.08)
  IN2 w0.124: v2(232.37,111.26) 234.11,109.52 234.11,106.28 234.33,106.07 236.95,106.07 237.45,106.56 242.42,106.56 244.44,104.54 255.39,104.54 255.85,104.09 258.22,104.09 260.29,102.02 260.29,99.57 261.26,98.59 261.26,95.88 v2(260.84,95.46)
  IN3 w0.135: v2(263.66,84.5) 263.59,84.58 261.22,84.58 259.69,83.04 255.41,83.04 254.75,83.7 251.76,83.7 250.68,84.78 250.68,85.46 v2(250.28,85.86)
  BOTTOM w0.112: v2(232.37,111.26) 231.88,111.75 JNGFF2.1 ; v2(263.66,84.5) 263.93,84.5 266.43,87 266.43,93.96 264.77,95.62 262.69,95.62 262.58,95.51 260.89,95.51 v2(260.84,95.46)
SM_RCOMP0: length 12.6
  TOP w0.381: RC5.1 120.48,84.73 v1(120.48,85.53) 120.48,87.48 v2(121.31,88.3)
  IN2 w0.305: v2(121.31,88.3) 121.25,88.3 120.29,89.27 120.29,93.26 121.76,94.74 v2(121.98,94.74)
  BOTTOM w0.254: UC1.AR18 122.42,95.08 v2(121.98,94.74)
SM_RCOMP1: length 11.5
  TOP w0.381: v2(122.22,87.64) 122.07,87.49 v1(122.07,86.6) 122.07,84.54 RC6.1
  IN2 w0.305: v2(121.98,94.1) 121.69,94.1 120.84,93.26 120.84,92.65 120.84,91.03 121.23,90.64 121.23,89.78 122.22,88.78 v2(122.22,87.64)
  BOTTOM w0.254: v2(121.98,94.1) 122.42,94.43 UC1.AT18
SM_RCOMP2: length 10.7
  TOP w0.381: RC7.1 v1(122.9,85.46) 122.9,86.98 v2(122.9,86.99)
  IN2 w0.305: v2(121.97,93.47) 121.76,93.47 121.45,93.16 121.45,91.97 122.55,90.87 122.55,89.81 123.16,89.19 123.16,87.25 v2(122.9,86.99)
  BOTTOM w0.254: UC1.AU18 121.98,93.47 v2(121.97,93.47)
SML0_SMBCLK: length 240.7
  TOP w0.112: UL1.28 247.28,130.77 v2(246.98,131.07)
  IN1 w0.119: v2(235.82,66.68) 235.63,66.86 235.46,66.86 235.25,66.66 235.25,65.27 230.57,60.59 226.76,60.59 226.04,61.31 219.83,61.31 219.38,60.86 215.39,60.86 214.57,61.68 179.26,61.68 178.11,62.83 174.36,62.83 170.91,66.28 164.37,66.28 162.85,67.79 150.82,67.79 147.97,70.64 147.97,85.05 148.26,85.33 148.26,87.64 147.34,88.56 147.34,90.91 147.93,91.49 147.93,93.41 148.64,94.12 149.29,94.12 149.54,94.37 149.54,95.47 148.99,96.02 148.99,101.56 146.4,104.14 144.9,104.14 144.22,103.47 142.19,103.47 141.73,103.01 140.96,103.01 v2(140.79,102.84)
  IN3 w0.135: v2(235.82,66.68) 235.99,66.85 236.41,66.85 237.2,67.64 238,67.64 240.61,70.25 240.61,77.06 238.53,79.13 238.53,79.86 238.07,80.33 235.99,80.33 235.36,80.96 235.36,90.06 238.5,93.21 238.5,98.25 240.62,100.36 240.62,106.46 240.03,107.05 240.03,108.78 236.88,111.93 236.88,126.81 239.94,129.87 245.39,129.87 246.02,130.5 246.4,130.5 v2(246.98,131.07)
  BOTTOM w0.076: UC1.R9 127.73,105.14 127.86,105.02 127.86,104.53 128.11,104.29 128.11,104.15 128.33,103.92 129.36,103.92 129.96,103.32 129.96,103.24 130.38,102.83 132.08,102.83 132.32,102.72 132.76,102.72 132.88,102.84 135.58,102.84 135.69,102.96 136.82,102.96 136.83,102.94 136.85,102.94
  BOTTOM w0.102: RC347.1 RC19.1
  BOTTOM w0.112: 136.85,102.94 138.02,102.94 138.21,103.13 139.22,103.13 139.33,103.01 140.61,103.01 v2(140.79,102.84) 140.97,103.02 141.14,103.02 141.69,102.47 CC318.1 142.56,102.39 RC19.1
SML0_SMBDATA: length 234
  TOP w0.112: v2(246.34,131.07) 245.83,130.57 245.83,129.68 246.08,129.43 UL1.31
  IN1 w0.119: v2(235.82,67.26) 235.66,67.11 235.35,67.11 235.01,66.76 235.01,65.38 230.47,60.84 226.86,60.84 226.14,61.56 219.73,61.56 219.28,61.11 215.49,61.11 214.67,61.92 179.36,61.92 178.21,63.07 174.46,63.07 171.01,66.53 164.47,66.53 162.96,68.04 150.92,68.04 148.22,70.74 148.22,84.94 148.5,85.23 148.5,87.74 147.59,88.66 147.59,90.81 148.17,91.39 148.17,93.31 148.74,93.88 149.39,93.88 149.78,94.27 149.78,95.57 149.23,96.12 149.23,101.66 146.51,104.39 144.8,104.39 144.12,103.71 142.09,103.71 141.63,103.26 140.96,103.26 v2(140.79,103.42)
  IN3 w0.135: v2(246.34,131.07) 246.34,130.87 246.23,130.77 245.91,130.77 245.28,130.14 239.83,130.14 236.62,126.92 236.62,111.83 239.77,108.68 239.77,106.94 240.36,106.36 240.36,100.47 238.24,98.35 238.24,93.32 235.09,90.17 235.09,80.85 235.88,80.06 237.96,80.06 238.27,79.75 238.27,79.02 240.34,76.95 240.34,70.35 237.89,67.9 237.09,67.9 236.3,67.12 235.96,67.12 v2(235.82,67.26)
  BOTTOM w0.076: UC1.W2 132.05,103.03 132.28,102.92 132.67,102.92 132.8,103.04 135.49,103.04 135.61,103.16 136.82,103.16 136.83,103.18 136.85,103.18
  BOTTOM w0.112: 136.85,103.18 137.92,103.18 138.11,103.37 139.32,103.37 139.43,103.25 140.61,103.25 v2(140.79,103.42) 140.95,103.26 RC20.1 RC348.1
SML1_SMBCLK: length 208.7
  TOP w0.112: v2(238.47,53.49) 238.29,53.31 238.29,51.45 236.26,49.42 187.26,49.42 185.41,51.27 180.87,51.27 178.68,53.46 178.68,56.49 179.14,56.95 179.14,60.66 176.53,63.26 176.53,64.23 v2(176.36,64.4) ; UE1.D8 v2(248.68,89.86)
  IN1 w0.119: v2(176.36,64.4) 176.53,64.57 176.53,65.16 175.65,66.03 173.6,66.03 172.3,67.32 164.92,67.32 163.41,68.83 151.26,68.83 148.98,71.11 148.98,84.06 149.36,84.44 149.36,92.35 150.78,93.77 150.78,95.34 150.68,95.43 150.68,99.63 150.01,100.3 150.01,102.6 147.37,105.24 145.99,105.24 144.97,106.26 142.61,106.26 142.42,106.07 141.3,106.07 v2(141.14,105.91)
  BOTTOM w0.076: 136.85,103.96 136.83,103.96 136.82,103.98 135.52,103.98 135.21,103.67 133.15,103.67 133.05,103.57 132.75,103.57 132.19,103.4 131.94,103.4 131.85,103.44 131.66,103.44 131.65,103.44 131.57,103.4 131.34,103.4 UC1.W3
  BOTTOM w0.112: 136.85,103.96 137.46,103.96 137.91,104.41 137.91,104.99 138.68,105.77 140.66,105.77 CC319.1 141.2,105.86 v2(141.14,105.91) 141.36,106.13 141.99,106.13 RC15.1 ; v2(238.47,53.49) 238.28,53.68 238.28,54.28 240.31,56.32 240.31,57.36 245.25,62.29 245.25,65.2 246.79,66.74 246.79,68.61 246.94,68.77 246.94,70.25 247.76,71.08 248.2,71.08 248.99,71.87 248.99,72.99 248.02,73.96 248.02,74.4 248.3,74.68 248.3,80.71 247.69,81.32 247.69,82.03 245.77,83.95 245.77,84.44 246.13,84.81 246.13,85.54 246.58,85.98 246.58,88 248.43,89.86 v2(248.68,89.86)
SML1_SMBDATA: length 212.9
  TOP w0.112: UE1.E11 v2(249.48,92.26) ; v2(237.88,53.49) 238.05,53.32 238.05,51.55 236.16,49.66 187.36,49.66 185.51,51.51 180.97,51.51 178.92,53.56 178.92,56.39 179.37,56.85 179.37,60.75 176.77,63.36 176.77,64.23 v2(176.94,64.4)
  IN1 w0.119: v2(176.94,64.4) 176.77,64.57 176.77,65.26 175.75,66.28 173.7,66.28 172.41,67.57 165.02,67.57 163.51,69.08 151.36,69.08 149.22,71.21 149.22,83.96 149.6,84.34 149.6,92.25 151.02,93.67 151.02,95.44 150.93,95.53 150.93,99.73 150.26,100.4 150.26,102.71 147.48,105.49 146.09,105.49 145.07,106.5 142.51,106.5 142.32,106.31 141.32,106.31 v2(141.14,106.49)
  BOTTOM w0.076: 136.85,104.2 136.83,104.2 136.82,104.18 135.43,104.18 135.13,103.88 133.1,103.88 132.97,103.74 132.75,103.74 132.29,103.61 132.16,103.57 131.99,103.57 131.83,103.62 131.63,103.62 131.53,103.57 131.23,103.57 UC1.V3
  BOTTOM w0.112: v2(249.48,92.26) 248.99,92.75 246.68,92.75 246.34,92.4 246.34,86.08 245.9,85.64 245.9,84.91 245.53,84.54 245.53,83.86 247.45,81.94 247.45,81.23 248.07,80.61 248.07,74.78 247.79,74.5 247.79,73.86 248.76,72.89 248.76,71.97 248.1,71.32 247.67,71.32 246.7,70.35 246.7,68.86 246.55,68.71 246.55,66.84 245.01,65.3 245.01,62.39 240.07,57.46 240.07,56.41 238.04,54.38 238.04,53.64 v2(237.88,53.49) ; RC17.1 141.73,106.36 141.27,106.36 v2(141.14,106.49) 140.65,106 138.58,106 137.67,105.09 137.67,104.51 137.36,104.2 136.85,104.2
SNB_+1VALWP: length 2
  TOP w0.112: 159.28,81.04 v1(161.31,81.04)
SNK0_CONFIG1: length 2.9
  TOP w0.102: v2(29.69,98.04) UT1.N4
  BOTTOM w0.112: RT337.1 RT129.1 29.74,97.13 30.02,97.41 v1(30.02,97.64) 30.02,97.7 v2(29.69,98.04)
SNUB_1.8VALW: length 1
  BOTTOM w0.508: PC506.1 171.4,63.71 171.4,63.54 PR502.2
SNUB_1V_PRIM: length 2.3
  TOP w0.112: PR409.2 v1(154.33,126.07)
  TOP w0.508: PR409.2 PC419.1
SNUB_1VS_VCCIO: length 2.1
  TOP w0.112: PC401.1 v1(136.49,130.17)
  TOP w0.508: PR405.2 138.47,130.17 PC401.1
SNUB_CHG1: length 1.9
  TOP w0.112: PR923.2 v1(40.85,66.8)
SNUB_CHG2: length 1.4
  TOP w0.112: PC941.1 v1(50.96,65.1)
SPKR: length 150.3
  TOP w0.112: v1(237.1,59.46) 236.69,59.87 v2(236.69,60.25) ; v2(253.49,67.12) 253.49,66.74 RA12.2 ; RC183.1 v2(140.68,85.51) 140.43,85.75 139.42,85.75 138.52,86.65 136.9,86.65 135.15,88.4 134.1,88.4 132.23,90.27 132.23,91.25 131.06,92.42 131.06,92.49 130.69,92.86 v2(130.36,92.86)
  IN1 w0.119: v2(253.49,67.12) 253.06,66.69 251.94,66.69 250.26,65.01 248.29,65.01 244.38,61.1 240.18,61.1 238.99,59.9 237.03,59.9 v2(236.69,60.25)
  IN2 w0.124: v2(140.68,85.51) 141.35,84.83 143.19,84.83 147.98,80.04 147.98,72.27 150.06,70.19 150.37,70.19 150.87,69.69 159.43,69.69 162.95,66.17 171.03,66.17 174.12,63.07 178.25,63.07 178.77,63.6 180.5,63.6 181.38,62.72 182.44,62.72 182.73,62.43 202.16,62.43 204.3,60.28 218.27,60.28 219.15,61.16 225.87,61.16 226.75,60.28 227.52,60.28 229.09,58.71 234.7,58.71 236.23,60.25 v2(236.69,60.25)
  BOTTOM w0.076: v2(130.36,92.86) 130.14,93.09 UC1.AW5
SPKR_R: length 2.9
  TOP w0.112: CA27.1 252.3,64.27 CA72.1 RA51.1 RA12.1
SRTCRST#: length 20.2
  TOP w0.112: RC56.1 130.39,82.64 130.39,83.91 CC24.1 129.82,86.13 129.51,86.43 129.51,89.27 126.25,92.53 125.38,92.53 124.83,93.08 124.55,93.08 124.4,93.23 124.4,94.52 124.32,94.6 v1(124.32,96.91) 124.15,97.08 123.66,97.08 123.27,96.68 v2(122.91,96.68)
  BOTTOM w0.102: UC1.AN18 122.63,96.4 v2(122.91,96.68)
SS_1V_PRIM: length 3.4
  BOTTOM w0.112: v1(158.04,133.06) 158.15,132.94 PC420.1
  BOTTOM w0.254: PC420.1 PR428.1 158.15,130.83 157.75,130.44 PU402.7
SS_1VS_VCCIO: length 3.6
  BOTTOM w0.112: PC410.1 142.21,134.3 v1(141.86,134.66)
  BOTTOM w0.254: PC410.1 PR427.1 142.21,132.17 141.88,131.83 PU401.7
SUSACK#: length 192.7
  TOP w0.107: UE1.K12 v2(254.3,93.08)
  IN1 w0.119: v2(133.83,89.23) 133.45,89.61 129.06,89.61 126.14,92.53 126.14,94.84 v2(125.66,95.32)
  IN2 w0.124: v2(254.3,93.08) 254.9,93.68 257.03,93.68 259.29,91.41 259.29,88.34 259.89,87.74 261.17,87.74 262.47,86.45 262.47,83.78 262.95,83.29 262.95,82.42 264.09,81.29 264.09,74.85 260.75,71.51 256.18,71.51 255.82,71.15 253.09,71.15 252.83,70.89 250.01,70.89 249.39,70.27 245.97,70.27 245.29,69.59 244.4,69.59 242.95,68.14 242.95,65.2 242.26,64.5 241.5,64.5 241.34,64.34 237.03,64.34 235.8,63.1 234.13,63.1 233.93,63.31 230.53,63.31 230.25,63.03 204.33,63.03 202.96,64.4 184.97,64.4 183.01,66.36 176.33,66.36 172.67,70.02 162.2,70.02 160.72,71.5 151.83,71.5 150.11,73.21 150.11,83.16 145.01,88.26 139.32,88.26 138.41,89.16 137.18,89.16 136.93,88.91 134.14,88.91 v2(133.83,89.23)
  BOTTOM w0.102: UC1.AP11 v2(125.66,95.32)
SUSCLK: length 296.4
  TOP w0.112: v2(171.78,61.33) 171.84,61.33 176.31,65.8 183.83,65.8 187.33,64.33 227.38,64.33 228.59,65.54 229.65,65.54 230.12,65.07 234.87,65.07 v1(235.63,65.83) 237.03,67.23 237.03,67.43 RZ56.2 ; v2(124.99,86.37) 124.29,85.67 124.29,82.7 RC48.1
  IN1 w0.119: v2(13.74,47.97) 20.99,47.97 23.09,50.06 31.23,50.06 35.2,54.04 41.45,54.04 42.21,54.8 49.63,54.8 50.14,54.29 51.71,54.29 52.78,53.22 58.8,53.22 61.47,55.89 62.84,55.89 63.6,56.66 65.3,56.66 65.87,57.22 69.27,57.22 69.51,56.98 71.62,56.98 72.54,57.9 72.54,62.43 71.97,63 71.97,65.61 73.29,66.92 141.77,66.92 142.77,65.92 143.94,65.92 144.46,66.44 v2(145.83,66.44) 145.86,66.44 145.91,66.39 145.91,63.93 147.74,62.1 157.08,62.1 157.59,62.61 160.62,62.61 162.94,60.29 v2(166.14,60.29) ; v2(137.31,81.16) 136.87,81.16 136.1,81.93 136.1,83.32 133.88,85.55 126.96,85.55 126.14,86.37 v2(124.99,86.37)
  IN3 w0.135: v2(143.2,80.78) 143.64,80.35 143.64,79.79 143.2,79.36 143.2,79 143.88,78.33 143.88,70.86 145.92,68.82 145.92,66.54 v2(145.83,66.44) ; v2(171.78,61.33) 171.37,60.91 166.77,60.91 v2(166.14,60.29)
  BOTTOM w0.076: 124.56,87.32 122.94,88.94 122.94,90.87 122.67,91.13 UC1.BA17
  BOTTOM w0.112: 124.56,87.32 124.67,87.21 124.67,86.69 v2(124.99,86.37) ; v2(143.2,80.78) 142.95,80.53 137.69,80.53 137.31,80.91 v2(137.31,81.16) ; RN99.2 13.41,48.3 v2(13.74,47.97)
SUSCLK_R: length 6.4
  BOTTOM w0.102: RN99.1 13.55,46.81 v1(13.55,46.43) 13.55,43.15 JNGFF3.68
SW2_DP1_AUXN: length 116.9
  TOP w0.104: RV70.1 106.41,131.03 106.41,130.81 106.22,130.62 v2(106.15,130.62) ; v2(39.9,98.76) 39.88,98.75 39.88,98.68 39.75,98.55 39.51,98.55 CT175.1
  IN3 w0.135: v2(39.9,98.76) 39.88,98.75 39.88,98.63 39.78,98.52 39.65,98.52 39.48,98.35 39.07,98.35 38.76,98.66 38.76,102.51 40.63,104.38 40.63,107.26 38.75,109.14 37.46,109.14 34.71,111.9 31.63,111.9 30.89,112.65 30.89,118.51 38.57,126.2 40.71,126.2 40.9,126.02 45.99,126.02 47.88,127.91 67.28,127.91 67.58,128.21 72.91,128.21 73.47,127.65 74.44,127.65 75.16,126.92 80.76,126.92 85.36,131.52 105.92,131.52 106.48,130.96 106.48,130.75 106.34,130.62 106.15,130.62 v2(106.15,130.62)
  BOTTOM w0.104: UV7.29 108.36,131.14 108.18,130.96 108.03,130.96 107.6,131.39 106.89,131.39 106.67,131.17 106.67,130.98 106.46,130.77 106.46,130.66 106.36,130.55 106.21,130.55 v2(106.15,130.62)
SW2_DP1_AUXN_C: length 9.4
  TOP w0.094: UT1.W12 32.61,101.61 v2(32.29,101.29)
  TOP w0.104: CT175.2 38.53,98.56 38.28,98.56 v2(38.08,98.76)
  IN1 w0.119: v2(32.29,101.29) 32.46,101.46 32.46,101.72 32.77,102.03 33.63,102.03 34.63,101.03 35.78,101.03 37.36,99.44 37.36,98.77 37.56,98.58 37.9,98.58 v2(38.08,98.76)
SW2_DP1_AUXP: length 116.7
  TOP w0.104: CT169.1 39.47,98.35 39.65,98.35 v2(39.88,98.11) ; RV76.1 106.87,131.04 v2(106.87,130.59)
  IN3 w0.135: v2(39.88,98.11) 38.97,98.11 38.52,98.56 38.52,102.61 40.38,104.48 40.38,107.16 38.65,108.9 37.36,108.9 34.61,111.66 31.53,111.66 30.64,112.55 30.64,118.61 38.47,126.45 40.81,126.45 41,126.26 45.89,126.26 47.78,128.15 67.18,128.15 67.48,128.45 73.01,128.45 73.57,127.89 74.54,127.89 75.26,127.16 80.66,127.16 85.26,131.76 106.02,131.76 106.72,131.06 106.72,130.74 v2(106.87,130.59)
  BOTTOM w0.104: v2(106.87,130.59) 106.87,131.08 106.97,131.19 107.48,131.19 v4(107.67,131) 107.92,130.74 UV7.28
SW2_DP1_AUXP_C: length 9.4
  TOP w0.094: UT1.Y12 33.2,101.67 33,101.67 32.94,101.61 v2(32.94,101.29)
  TOP w0.104: CT169.2 38.54,98.36 38.27,98.36 v2(38.08,98.18)
  IN1 w0.119: v2(38.08,98.18) 37.9,98.36 37.47,98.36 37.14,98.68 37.14,99.35 35.69,100.81 34.54,100.81 33.54,101.81 32.86,101.81 32.68,101.63 32.68,101.48 32.7,101.46 32.7,101.38 32.8,101.29 v2(32.94,101.29)
SW2_DP1_CADET: length 4
  TOP w0.112: v1(110.79,131.04) 110.5,131.33 RV73.1 110.5,132.63 v2(109.81,133.33)
  BOTTOM w0.107: UV7.33 110.31,132.82 v2(109.81,133.33)
SW2_DP1_HPD: length 125.2
  TOP w0.102: UT1.Y6 33.26,99.01 v2(32.94,99.33)
  TOP w0.112: v2(74.32,130.01) 74.83,129.5 75.69,129.5 76.5,128.69 79.69,128.69 82.09,131.09 82.09,133.06 83.44,134.4 111.89,134.4 112.09,134.2 112.09,133.26 v2(112.11,133.23)
  IN2 w0.124: v2(35.23,105.4) 32.1,108.52 30.89,108.52 30.12,109.28 30.12,111.39 29.74,111.77 29.74,123.33 31.19,124.78 34.47,124.78 37.03,127.34 45.69,127.34 46.67,128.32 61.16,128.32 62.27,129.42 66.78,129.42 66.93,129.58 73.89,129.58 v2(74.32,130.01)
  BOTTOM w0.107: UV7.38 112.31,133.04 v2(112.11,133.23)
  BOTTOM w0.112: v2(32.94,99.33) 33.31,99.71 33.68,99.71 34.14,99.25 RT29.1 34.09,99.73 34.09,100.54 34.57,101.03 34.57,101.69 35.8,102.92 35.8,104.82 v2(35.23,105.4) 35.23,106.4 v1(33.68,107.95)
SW2_DP1_N0: length 123.3
  TOP w0.104: v2(37.45,103.2) 37.26,103.02 36.94,103.02 CT176.1
  IN3 w0.135: v2(112.52,134) 112.6,134 112.68,133.91 112.68,133.82 112.86,133.64 112.86,132.9 110.55,130.58 108.16,130.58 105.84,132.91 83.86,132.91 83.16,132.21 83.16,130.63 80.38,127.85 75.58,127.85 74.7,128.73 73.74,128.73 73.32,129.15 67.16,129.15 66.88,128.87 47.52,128.87 45.71,127.06 41.23,127.06 41.1,127.18 38.15,127.18 35.18,124.22 30.86,124.22 29.88,123.24 29.88,112.18 31.12,110.95 34.33,110.95 37.06,108.21 38.35,108.21 39.7,106.87 39.7,104.79 37.97,103.06 37.59,103.06 v2(37.45,103.2)
  BOTTOM w0.104: v2(112.52,134) 112.53,134 112.9,133.62 112.9,132.88 112.71,132.68 UV7.39
SW2_DP1_N0_C: length 2.4
  TOP w0.076: 35.35,102.95 35.33,102.95 35.32,102.93 34.89,102.93 34.59,103.23 34.36,103.23 34.31,103.18 34.31,103.1 UT1.AC15
  TOP w0.104: CT176.2 36.13,103.2 35.88,102.95 35.35,102.95
SW2_DP1_N1: length 119.9
  TOP w0.104: CT171.1 38.94,103.88 39.09,103.88 39.34,104.13 39.34,104.53 39.27,104.6 39.06,104.6 38.82,104.84 38.82,104.93 38.74,105 v2(38.65,105)
  IN3 w0.135: v2(38.65,105) 38.65,105.03 38.95,105.34 38.95,106.03 38.98,106.06 38.98,106.56 38.01,107.53 34.73,107.53 32.03,110.23 30.79,110.23 29.12,111.9 29.12,123.55 30.47,124.9 34.88,124.9 37.9,127.92 41.33,127.92 41.46,127.79 45.48,127.79 47.24,129.55 65.91,129.55 66.31,129.94 73.54,129.94 74.04,129.45 74.95,129.45 75.87,128.53 80.1,128.53 82.42,130.86 82.42,132.63 83.39,133.59 106.22,133.59 107.72,132.09 110.22,132.09 110.22,132.09 110.32,132.09 111.17,132.94 111.17,133.82 v2(111.07,133.92)
  BOTTOM w0.104: v2(111.07,133.92) 111.11,133.92 111.25,133.78 111.25,133.75 111.33,133.67 111.33,133.33 111.51,133.15 UV7.36
SW2_DP1_N1_C: length 4.4
  TOP w0.076: UT1.AC17 34.33,104 34.33,104.09 34.38,104.15 34.61,104.15 34.73,104.03 34.73,103.94 34.79,103.88 34.79,103.88 34.83,103.84 35.32,103.84 35.33,103.86 35.35,103.86
  TOP w0.104: CT171.2 37.97,103.86 35.35,103.86
SW2_DP1_N2: length 121.8
  TOP w0.104: CT168.1 36.9,104.65 37.25,104.65 37.46,104.86 v2(37.46,104.86)
  IN3 w0.135: v2(109.83,133.99) 109.93,133.99 110.07,133.86 110.07,133.74 110.25,133.56 110.25,133.07 109.97,132.79 109.87,132.79 108.01,132.79 106.52,134.28 83.05,134.28 81.71,132.94 81.71,131.11 79.82,129.22 76.17,129.22 72.72,132.68 49.4,132.68 45.26,128.53 41.69,128.53 41.39,128.83 37.8,128.83 35.01,126.05 30.53,126.05 28.29,123.81 28.29,111.68 29.96,110.02 29.96,109.72 30.58,109.09 32.13,109.09 34.39,106.83 37.67,106.83 37.89,106.61 37.89,104.83 37.77,104.71 37.59,104.71 37.46,104.84 v2(37.46,104.86)
  BOTTOM w0.104: UV7.34 110.71,132.96 110.09,133.58 110.09,133.73 v2(109.83,133.99)
SW2_DP1_N2_C: length 2.5
  TOP w0.076: UT1.AC19 34.42,104.83 34.28,104.83 34.23,104.88 34.23,104.98 34.31,105.06 34.61,105.06 34.83,104.85 35.32,104.85 35.33,104.86 35.35,104.86
  TOP w0.104: 35.35,104.86 35.63,104.86 35.83,104.67 35.94,104.67 CT168.2
SW2_DP1_N3: length 120.6
  TOP w0.104: v2(37.45,105.8) 37.3,105.94 36.82,105.94 CT170.1
  IN3 w0.135: v2(108.58,133.92) 108.58,133.65 108.47,133.54 108.25,133.54 106.82,134.97 81.9,134.97 80.97,134.04 80.97,131.34 79.54,129.91 76.48,129.91 73.02,133.36 49.12,133.36 45,129.24 42.1,129.24 41.33,130.01 37.94,130.01 34.67,126.74 30.15,126.74 27.47,124.06 27.47,111.29 27.98,110.78 27.98,109.11 28.69,108.39 31.66,108.39 34.24,105.82 37.42,105.82 v2(37.45,105.8)
  BOTTOM w0.104: v2(108.58,133.92) 108.84,133.66 108.84,133.43 109.51,132.76 UV7.31
SW2_DP1_N3_C: length 2.6
  TOP w0.076: 35.35,106.01 35.33,106.01 35.34,106.02 35.34,106.02 35.18,106.02 34.94,105.79 34.86,105.79 34.59,105.52 34.26,105.52 34.21,105.57 34.21,105.67 34.29,105.75 UT1.AC21
  TOP w0.104: CT170.2 35.89,106.01 35.35,106.01
SW2_DP1_P0: length 123.3
  TOP w0.104: v2(37.45,102.62) 37.25,102.82 36.96,102.82 CT177.1
  IN3 w0.135: v2(37.45,102.62) 37.64,102.82 38.07,102.82 39.94,104.69 39.94,106.97 38.45,108.46 37.16,108.46 34.43,111.19 31.22,111.19 30.12,112.28 30.12,123.14 30.96,123.98 35.28,123.98 38.25,126.94 41,126.94 41.13,126.82 45.81,126.82 47.62,128.62 66.98,128.62 67.26,128.91 73.22,128.91 73.64,128.48 74.6,128.48 75.48,127.61 80.48,127.61 83.41,130.53 83.41,132.11 83.96,132.67 105.74,132.67 108.06,130.34 110.65,130.34 113.1,132.8 v2(113.1,134)
  BOTTOM w0.104: v2(113.1,134) 113.1,132.7 113.11,132.7 UV7.40
SW2_DP1_P0_C: length 2.4
  TOP w0.076: UT1.AB15 34.14,102.81 34.2,102.75 34.8,102.75 34.81,102.75 35.32,102.75 35.33,102.73 35.35,102.73
  TOP w0.104: 35.35,102.73 36.08,102.73 CT177.2
SW2_DP1_P1: length 120
  TOP w0.104: v2(39.23,105) 39.23,104.9 39.33,104.8 39.36,104.8 39.56,104.59 39.56,104.06 39.17,103.68 38.94,103.68 CT172.1
  IN3 w0.135: v2(111.66,133.92) 111.5,133.76 111.5,133.74 111.42,133.66 111.42,132.84 110.42,131.85 110.12,131.85 110.12,131.85 107.62,131.85 106.12,133.35 83.49,133.35 82.67,132.53 82.67,130.76 80.2,128.29 75.77,128.29 74.85,129.21 73.94,129.21 73.44,129.7 66.41,129.7 66.01,129.31 47.34,129.31 45.58,127.55 41.36,127.55 41.23,127.68 38,127.68 34.98,124.66 30.57,124.66 29.36,123.45 29.36,112 30.89,110.48 32.13,110.48 34.83,107.77 38.11,107.77 39.22,106.66 39.22,105.96 39.19,105.93 39.19,105.24 39.14,105.18 39.14,105.1 v2(39.23,105)
  BOTTOM w0.104: UV7.37 111.91,132.68 111.71,132.88 111.71,133.23 111.53,133.41 111.53,133.79 v2(111.66,133.92)
SW2_DP1_P1_C: length 4.4
  TOP w0.076: UT1.AB17 34.18,103.69 34.72,103.69 34.76,103.66 35.34,103.66 35.34,103.65 35.33,103.64 35.35,103.64
  TOP w0.104: 35.35,103.64 38.03,103.64 CT172.2
SW2_DP1_P2: length 121.9
  TOP w0.104: v2(37.47,104.26) 37.28,104.45 36.87,104.45 CT174.1
  IN3 w0.135: v2(37.47,104.26) 37.47,104.28 37.65,104.47 37.87,104.47 38.13,104.73 38.13,106.71 37.77,107.07 34.49,107.07 32.23,109.33 30.68,109.33 30.2,109.82 30.2,110.12 28.54,111.78 28.54,123.71 30.63,125.8 35.11,125.8 37.9,128.59 41.29,128.59 41.59,128.29 45.36,128.29 49.5,132.43 72.62,132.43 76.07,128.98 79.92,128.98 81.95,131.01 81.95,132.84 83.15,134.04 106.42,134.04 107.91,132.55 109.77,132.55 110.07,132.55 110.49,132.97 v2(110.49,133.92)
  BOTTOM w0.104: UV7.35 111.11,132.67 110.91,132.86 110.91,133.05 110.31,133.64 110.31,133.82 110.42,133.92 v2(110.49,133.92)
SW2_DP1_P2_C: length 2.5
  TOP w0.076: UT1.AB19 34.1,104.7 34.2,104.59 34.61,104.59 34.69,104.66 35.32,104.66 35.33,104.65 35.34,104.65 35.35,104.66
  TOP w0.104: 35.35,104.66 35.36,104.66 35.53,104.66 35.74,104.46 35.94,104.46 CT174.2
SW2_DP1_P3: length 120.6
  TOP w0.104: CT173.1 36.89,106.16 36.94,106.16 36.96,106.14 37.21,106.14 v2(37.45,106.38)
  IN3 w0.135: v2(109.17,133.92) 109.01,133.76 109.01,133.74 108.83,133.56 108.83,133.55 108.57,133.3 108.15,133.3 106.72,134.73 82,134.73 81.21,133.94 81.21,131.24 79.64,129.67 76.38,129.67 72.92,133.12 49.22,133.12 45.1,129 42,129 41.23,129.77 38.04,129.77 34.77,126.5 30.25,126.5 27.71,123.96 27.71,111.39 28.22,110.88 28.22,109.21 28.79,108.63 31.76,108.63 34.34,106.06 37.11,106.06 37.2,106.15 37.2,106.15 37.27,106.22 37.32,106.22 37.45,106.34 v2(37.45,106.38)
  BOTTOM w0.104: v2(109.17,133.92) 109.04,133.79 109.04,133.51 109.91,132.65 UV7.32
SW2_DP1_P3_C: length 2.4
  TOP w0.076: UT1.AB21 34.18,105.97 34.87,105.97 35.1,106.21 35.32,106.21 35.33,106.22 35.35,106.22
  TOP w0.104: CT173.2 35.94,106.22 35.35,106.22
SW2_DP2_AUXN: length 174
  TOP w0.104: v2(106.74,130) 106.74,129.65 RV71.1 ; v2(231.15,75.72) 231.15,75.56 231.22,75.5 v4(233.13,75.5) 233.95,75.5 234.58,76.13 234.84,76.13 234.92,76.21 234.92,76.54 234.97,76.59 CV150.1
  IN3 w0.135: v2(106.74,130) 106.68,130 106.56,129.88 106.56,129.71 106.7,129.57 107.61,129.57 107.94,129.9 119.12,129.9 119.44,129.58 121.26,129.58 124.65,126.19 129.82,126.19 131.8,124.2 134.64,124.2 135.06,123.79 138.25,123.79 138.89,123.15 149.38,123.15 155.08,117.45 156.45,117.45 161.31,112.58 161.31,111.43 166.8,105.94 166.8,99.43 arc(169.2,87.35) 176.04,77.11 176.89,76.26 arc(185.49,70.52) 195.63,68.5 204.78,68.5 205.63,67.65 219.78,67.65 222.26,70.14 222.26,71.74 223.3,72.78 227.52,72.78 229.6,74.86 229.6,75.1 229.86,75.35 230.91,75.35 231.15,75.59 v2(231.15,75.72)
  BOTTOM w0.104: UV7.27 108.36,130.34 108.26,130.24 107.93,130.24 107.29,129.6 106.63,129.6 106.55,129.68 106.55,129.89 106.66,130 v2(106.74,130)
SW2_DP2_AUXN_C: length 5.2
  TOP w0.104: v2(237.54,76.44) 237.28,76.19 236.7,76.19 CV150.2
  BOTTOM w0.104: JNGFF1.20 240.03,75.9 239.88,75.75 239.5,75.75 238.99,76.26 237.72,76.26 v2(237.54,76.44)
SW2_DP2_AUXP: length 174.2
  TOP w0.104: v2(106.16,130) 106.45,129.7 106.45,129.56 RV77.1 ; CV149.1 235.15,75.93 234.67,75.93 234.03,75.3 233.45,75.3 233.42,75.27 232.85,75.27 232.82,75.3 231.44,75.3 v2(231.15,75)
  IN3 w0.135: v2(231.15,75) 231.05,75.11 229.96,75.11 229.84,75 229.84,74.76 227.62,72.54 223.4,72.54 222.5,71.64 222.5,70.04 219.88,67.41 205.53,67.41 204.68,68.26 195.63,68.26 arc(185.39,70.29) 176.72,76.09 175.87,76.94 arc(168.98,87.25) 166.56,99.43 166.56,105.84 161.07,111.33 161.07,112.48 156.35,117.21 154.98,117.21 149.28,122.91 138.79,122.91 138.15,123.55 134.96,123.55 134.54,123.96 131.7,123.96 129.72,125.94 124.55,125.94 121.16,129.34 119.34,129.34 119.02,129.66 108.04,129.66 107.71,129.33 106.6,129.33 106.32,129.61 106.32,129.83 v2(106.16,130)
  BOTTOM w0.104: UV7.26 108.33,129.94 108.23,130.04 108.01,130.04 107.37,129.4 106.55,129.4 106.35,129.6 106.35,129.8 v2(106.16,130)
SW2_DP2_AUXP_C: length 5.2
  TOP w0.104: CV149.2 236.58,75.99 237.4,75.99 v2(237.54,75.86)
  BOTTOM w0.104: JNGFF1.22 240.03,75.4 239.88,75.55 239.42,75.55 238.91,76.06 237.74,76.06 v2(237.54,75.86)
SW2_DP2_CADET: length 3.7
  TOP w0.112: v1(113.08,131.04) 113.26,131.21 RV74.1 113.59,132.22 v2(114.45,133.08)
  BOTTOM w0.107: UV7.43 114.31,132.94 v2(114.45,133.08)
SW2_DP2_HPD: length 169.7
  IN1 w0.119: v2(116.31,133.11) 116.31,134.25 117.63,135.57 144.19,135.57 148.54,131.23 151.69,131.23 152.68,132.22 155.85,132.22 v2(156.42,132.79)
  IN2 w0.124: v2(156.42,132.79) 157.41,131.8 158.87,131.8 160.62,130.06 161.08,130.06 164.02,127.11 164.02,111.14 169.16,106.01 169.16,90.9 171.06,89 171.06,86.47 173.41,84.12 173.41,82.1 182.5,73 185.39,73 187.52,70.88 213.58,70.88 214.59,71.89 216.6,71.89 218.09,73.38 v2(225.77,73.38)
  BOTTOM w0.107: UV7.48 v2(116.31,133.11)
  BOTTOM w0.112: JNGFF1.31 v1(226.87,73.15) 225.99,73.15 v2(225.77,73.38)
SW2_DP2_N0: length 162.1
  TOP w0.104: CV156.1 235.21,72.8 v4(232.1,72.8) 231.17,72.8 227.97,69.6 226.76,69.6 226.03,68.87 218.81,68.87 217.93,69.75 217.93,70.92 v2(217.98,70.97)
  IN3 w0.135: v2(118.22,133.91) 118.32,133.81 118.32,133.37 118.64,133.06 122.79,133.06 123.43,133.69 126.8,133.69 132.65,127.84 138.74,127.84 139.36,128.47 144.45,128.47 145.94,126.98 147.83,126.98 148.4,126.41 149.92,126.41 154.11,122.22 156.16,122.22 164.46,113.92 164.46,111.87 169.3,107.03 169.3,99.43 arc(171.51,88.3) 177.81,78.88 178.49,78.2 arc(186.48,72.86) 195.89,70.99 206.12,70.99 206.89,70.22 217.57,70.22 217.8,70.45 217.8,70.79 v2(217.98,70.97)
  BOTTOM w0.104: UV7.49 116.71,132.83 116.98,133.1 118.07,133.1 118.26,133.29 118.26,133.87 v2(118.22,133.91)
SW2_DP2_N0_C: length 5.1
  TOP w0.104: v2(237.39,72.82) 237.2,72.63 236.64,72.63 CV156.2
  BOTTOM w0.104: v2(237.39,72.82) 237.63,72.58 239.29,72.58 239.46,72.75 240.15,72.75 240.3,72.9 JNGFF1.32
SW2_DP2_N1: length 164.6
  TOP w0.104: v2(219.19,70.97) 219,70.78 219,70.09 219.52,69.56 225.86,69.56 226.5,70.21 227.71,70.21 228.37,70.87 228.37,73.14 229.66,74.43 235.06,74.43 CV152.1
  IN3 w0.135: v2(219.19,70.97) 219,70.78 219,70.1 218.41,69.52 206.54,69.52 205.74,70.31 195.85,70.31 arc(186.21,72.23) 178.04,77.69 177.33,78.39 arc(170.89,88.04) 168.62,99.43 168.62,106.72 163.74,111.6 163.74,113.68 155.96,121.46 153.88,121.46 149.65,125.69 147.82,125.69 147.22,126.29 145.27,126.29 144.94,126.62 139.57,126.62 139.05,127.14 132.05,127.14 126.85,132.34 117.58,132.34 116.98,132.94 116.98,133.85 v2(116.81,134.02)
  BOTTOM w0.104: UV7.46 115.51,132.69 115.59,132.77 115.59,133.31 116.02,133.74 116.53,133.74 v2(116.81,134.02)
SW2_DP2_N1_C: length 5.1
  TOP w0.104: CV152.2 236.64,74.41 237.17,74.41 v2(237.36,74.6)
  BOTTOM w0.104: v2(237.36,74.6) 237.56,74.4 239.55,74.4 239.7,74.25 240.07,74.25 240.22,74.4 JNGFF1.26
SW2_DP2_N2: length 159.3
  IN3 w0.135: v2(114.86,133.88) 115.03,133.71 115.03,132.9 116.28,131.65 125.86,131.65 128.51,128.99 128.98,128.99 131.69,126.29 134.34,126.29 135.64,124.99 149.36,124.99 153.67,120.69 155.77,120.69 162.84,113.62 162.84,111.52 167.93,106.42 167.93,99.43 arc(170.25,87.78) 176.84,77.91 177.63,77.12 arc(185.94,71.57) 195.74,69.62 205.43,69.62 206.22,68.82 219.31,68.82 221.11,70.62 221.11,72.34 223.42,74.65 227.78,74.65 228.03,74.9 228.03,75.16 v2(228.21,75.33)
  BOTTOM w0.104: UV7.44 114.71,132.69 114.91,132.88 114.91,133.21 115.06,133.37 115.06,133.68 v2(114.86,133.88) ; v2(228.21,75.33) 228.01,75.14 228.01,74.61 228.16,74.47 229.16,74.47 CV148.1
SW2_DP2_N2_C: length 3.2
  BOTTOM w0.104: CV148.2 230.75,74.48 232.45,74.48 232.61,74.65 JNGFF1.25
SW2_DP2_N3: length 162.4
  IN3 w0.135: v2(113.62,133.67) 113.78,133.51 113.78,132.5 115.93,130.34 119.58,130.34 119.89,130.03 121.63,130.03 124.21,127.46 129.35,127.46 131.28,125.53 134.01,125.53 135.24,124.29 149.07,124.29 153.36,120.01 155.43,120.01 161.99,113.45 161.99,111.38 167.25,106.12 167.25,99.43 arc(169.62,87.52) 176.36,77.42 177.16,76.62 arc(185.68,70.94) 195.72,68.94 205.04,68.94 205.84,68.14 219.61,68.14 221.79,70.32 221.79,72.01 223.6,73.81 227.93,73.81 228.98,74.87 228.98,76.16 228.68,76.46 228.42,76.46 v2(228.22,76.66)
  BOTTOM w0.104: UV7.41 113.51,132.7 113.61,132.8 113.61,133.13 113.82,133.34 113.82,133.48 v2(113.62,133.67) ; CV145.1 229.26,76.55 228.33,76.55 v2(228.22,76.66)
SW2_DP2_N3_C: length 3.4
  BOTTOM w0.104: CV145.2 230.77,76.43 230.87,76.43 230.93,76.49 232,76.49 232.49,76 232.58,76 232.73,76.15 JNGFF1.19
SW2_DP2_P0: length 162.1
  TOP w0.104: v2(217.4,70.97) 217.73,70.64 217.73,69.67 218.72,68.67 226.12,68.67 226.84,69.4 228.05,69.4 231.25,72.6 231.79,72.6 231.82,72.57 232.39,72.57 232.42,72.6 234.86,72.6 CV157.1
  IN3 w0.135: v2(118.81,133.91) 118.58,133.68 118.58,133.48 118.76,133.3 122.69,133.3 123.33,133.93 126.9,133.93 132.75,128.08 138.64,128.08 139.26,128.71 144.55,128.71 146.04,127.22 147.93,127.22 148.5,126.66 150.02,126.66 154.21,122.46 156.26,122.46 164.71,114.02 164.71,111.97 169.54,107.13 169.54,99.43 arc(171.74,88.4) 177.99,79.05 178.66,78.37 arc(186.57,73.09) 195.89,71.23 206.22,71.23 206.99,70.46 217.47,70.46 217.56,70.55 217.56,70.8 v2(217.4,70.97)
  BOTTOM w0.104: UV7.50 117.11,132.61 116.99,132.73 116.99,132.83 117.06,132.9 118.15,132.9 118.46,133.21 118.46,133.57 118.8,133.91 v2(118.81,133.91)
SW2_DP2_P0_C: length 5
  TOP w0.104: v2(237.39,72.24) 237.2,72.43 236.64,72.43 CV157.2
  BOTTOM w0.104: JNGFF1.34 240.28,72.4 240.13,72.55 239.55,72.55 239.38,72.38 237.53,72.38 v2(237.39,72.24)
SW2_DP2_P1: length 164.5
  TOP w0.104: v2(218.61,70.97) 218.8,70.78 218.8,70.01 219.44,69.36 225.94,69.36 226.59,70.01 227.8,70.01 228.57,70.79 228.57,73.06 229.75,74.23 235.01,74.23 CV153.1
  IN3 w0.135: v2(117.4,134.02) 117.23,133.85 117.23,133.04 117.68,132.59 126.95,132.59 132.15,127.38 139.15,127.38 139.67,126.86 145.04,126.86 145.37,126.53 147.32,126.53 147.92,125.93 149.75,125.93 153.98,121.7 156.06,121.7 163.98,113.78 163.98,111.7 168.86,106.82 168.86,99.43 arc(171.11,88.14) 177.5,78.57 178.21,77.86 arc(186.3,72.45) 195.85,70.55 205.84,70.55 206.64,69.76 218.31,69.76 218.76,70.2 218.76,70.82 v2(218.61,70.97)
  BOTTOM w0.104: UV7.47 115.91,132.68 115.79,132.8 115.79,133.23 116.11,133.54 116.91,133.54 v2(117.4,134.02)
