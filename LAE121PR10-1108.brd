# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8V_RUN: length 169
  TOP w0.254: 213.41,51.55 213.41,52.16 212.67,52.89 206.97,52.89 206.37,53.49 205.29,53.49 203.03,55.75 203.03,56.74 201.98,57.8 201.98,59.55 200.86,60.67 186.05,60.67 v2(183.26,63.46)
  TOP w0.508: v2(264.98,54.99) 264.69,55.28 RA3.2 264.76,55.83 CA65.1 CA66.1 ; v2(228,51.48) 228,51.16 227.52,50.68 223.73,50.68 221.63,52.77 219.37,52.77 218.04,51.44 v3(217.2,51.44) 213.93,51.44
  IN2 w0.254: v2(141.35,96.33) 141.57,96.54 141.57,99.2 142.21,99.85 142.96,99.85 143.89,98.92 146.4,98.92 147.6,97.72 149.5,97.72 150.19,97.04 150.19,93.66 149.62,93.1 149.62,91.56 150.24,90.94 152.49,90.94 153.64,89.79 160.41,89.79 161.03,89.17 162.79,89.17 v2(162.85,89.24)
  BOTTOM w0.254: RC363.2 RC362.2 140.98,96.8 141.35,96.43 v2(141.35,96.33) ; v2(162.85,89.24) 162.95,89.14 164.84,89.14 165.61,88.38 165.61,81.39 166.78,80.22 171.78,80.22 183.26,68.74 v2(183.26,63.46)
  BOTTOM w0.508: v2(264.98,54.99) 263.99,54 263.99,53.22 262.64,51.87 256.37,51.87 254.6,50.09 229.38,50.09 v2(228,51.48)
+1.8V_RUN_AUDIO: length 7.8
  TOP w0.127: v1(263.54,53.69) 263.26,53.97 CA69.1
  TOP w0.203: UA1.40 260.92,59.34 261.31,58.94 v2(261.47,58.94) ; UA1.36 259.53,56.99 259.61,56.91 v2(259.99,56.91)
  IN2 w0.508: v2(261.47,58.94) 260.96,58.94 259.99,57.97 v2(259.99,56.91) 261.62,56.91 v2(261.67,56.96)
+1.8V_RUN_CARD: length 20.3
  TOP w1.016: 297.71,59.04 295.13,59.04 293.64,60.54 285.93,60.54 v1(284.05,62.42) 284.02,62.42 283.21,63.23
  IN2 w1.016: 276.27,61.56 277.32,61.56 278.71,62.95 279.75,62.95
  vias: v2(275.66,61.78) v2(275.66,61.2) v2(280.63,63.09) v2(281.09,63.43)
+1.8V_RUN_UZ8:
  vias: v1(209.85,52.36)
+1.8VALWP: length 11.7
  BOTTOM w0.254: 178.21,62.24 179.41,63.45 179.41,64.97 v1(177.47,66.91) 175.39,69 173.66,69 173.56,68.9 PC503.1 PR501.1
+1VALWP: length 8
  BOTTOM w0.254: PR306.1 154.33,87.95 PC307.1 154.34,88.48 v1(155.19,89.32) 155.51,89.65 160.45,89.65
  vias: v2(161.5,87.73) v2(161.5,87.12) v2(161.5,86.49) v2(161.5,85.85)
+1VALWP_B+: length 0.8
  TOP w0.127: v2(153.22,83.04) v1(152.39,83.04)
  vias: v2(153.22,82.43)
+1VS_VCCIOP: length 6.2
  BOTTOM w0.254: PC406.1 134.77,131.98 135.72,132.93 v3(136.14,132.93) 136.65,132.93 136.92,132.66 PR421.1
+2.5V_MEM: length 1.9
  TOP w0.127: v3(145.62,64.25) 145.74,64.12 PJP506.2
  vias: v2(143.28,62.24) v2(143.28,61.61)
+2.5V_VIN:
  vias: v1(152.58,60.11)
+3.3V_1.8V_ESPI: length 1.9
  TOP w0.127: RC21.2 146.56,84.72 v1(146.89,85.05)
+3.3V_1.8V_PGPPA: length 34.9
  TOP w0.254: 146.65,82.62 146.58,82.69 147.34,83.45 147.34,85.41 v1(146.19,86.56) 145.9,86.85 144.24,86.85 143.95,86.56 141.75,86.56 141.42,86.89 139.73,86.89 138.88,87.74 137.51,87.74 136.99,88.26 136.99,89.29 v2(136.3,89.99)
  IN1 w0.254: v2(124.73,97.25) 125.28,97.8 126.13,97.8 127.02,96.92 127.02,96.46 127.02,96.46 127.02,93.09 129.48,90.64 135.65,90.64 v2(136.3,89.99)
  BOTTOM w0.254: v2(124.73,97.25) 124.73,97.38 UC1.AK15
+3.3V_1.8V_PGPPG: length 18
  TOP w0.254: v2(136.75,99.9) 136.75,99.94 137.01,100.2 CC326.1 137.02,100.86 RC235.2 137.9,100.85 RC234.2
  IN2 w0.254: v2(136.75,99.9) 136.75,99.27 135.25,97.77 132.29,97.77 130.4,99.67 130.01,100.06 125.25,100.06 v2(124.6,100.7)
  BOTTOM w0.254: v2(124.6,100.7) 124.6,100.8 124.29,101.12 UC1.AD15
+3.3V_ALW: length 373.9
  TOP w0.127: CE61.1 v3(272.81,87.3)
  TOP w0.254: v2(261.49,81.09) 261.14,81.09 RE37.2 ; UE2.18 265.56,92.72 265.29,92.99 CE1.1 CE2.1 263.59,92.12
  TOP w0.305: JAPS1.3 v2(263.56,108.96) ; JAPS1.7 261.56,108.9 v2(261.62,108.96)
  TOP w0.356: v2(249.34,102.13) 249.34,102.5 RE79.1
  TOP w0.381: RE25.1 258.42,96.98 RE35.2 RE38.2 RE8.2 256.63,97.42 256.82,97.61 RE300.1 257.66,97.85 v2(257.71,97.8) ; RE91.2 RE83.2 250.85,99.15 250.54,99.45 RE63.2 v2(251.17,99.77) ; UE4.5 269.88,98.83 269.82,98.9 UE3.5 268.24,99.16 CE53.1 268.24,100.68 RE69.1 ; RC68.2 142.63,81.39 v2(143.2,81.39) ; UZ10.5 265.72,84.83 ; 265.72,84.83 265.73,84.85 265.73,85.53 265.63,85.63 v2(265.62,85.63) ; 265.72,84.83 CZ93.1 ; PR1231.2 50.06,53.03 v2(49.62,53.48) 48.86,54.24 46.89,54.24 46.57,53.92 46.57,53.16 47.08,52.65 PR1233.2 PR1230.2 45.88,52.4 45.03,52.4 PR1232.2 44.47,52.09 PR1234.2 43.71,51.59 v2(43.71,52.21) ; RE84.2 249.53,101.94 v2(249.34,102.13) ; UZ34.5 141.49,67.7 CZ104.1 ; RE12.2 v2(261.52,79.96) ; v2(38.89,78.46) 38.89,79.31 38.51,79.69 RT68.2 ; v2(258.66,80.27) RE10.2 RE43.2 ; v2(55.09,51.47) 54.82,51.74 PR933.1 ; RE362.2 248.79,77.72 RE343.2 248.8,77.16 v2(248.72,77.07) ; v2(239.8,95.39) RE348.2 ; CE52.1 264.83,99.12 264.99,98.96 UE5.5 ; QZ2.2 v2(270.34,83.89) ; UE6.5 v2(269.52,80.73)
  TOP w0.457: v2(265.58,88.15) RE13.1 RE15.1 ; RE376.2 RE377.2 255.17,106.78 v2(255.17,107.28)
  TOP w0.508: RE5.2 247.8,98.13 247.17,97.5 RE301.2 RE21.2 v2(246.28,97.8) 246.28,98.36 245.74,98.89 CE6.1 244.94,98.89 244.61,98.56 UE7.5 ; RE11.2 v2(247.04,79.39) ; PR404.1 140.36,133.75 ; 140.36,133.75 PR414.1 v2(144.69,133.75) ; 140.36,133.75 138.77,135.34 124.66,135.34 123.93,134.61 123.93,133.56 121.64,131.28 v2(121.64,130.72) ; v2(43.81,118.04) 43.81,118.29 44.09,118.57 PR4.2 ; RZ9.1 234.61,52.51 235.11,53.02 235.11,54.43 234.34,55.21 RZ8.1 233.32,57.19 232.59,57.92 228.85,57.92 ; RE17.1 269.67,87.91 v2(269.67,87.48) ; CE52.1 264.96,100.15 v2(265.45,100.15) ; PR410.1 v2(165.25,129.3) ; v2(221.13,55.95) 221.33,55.75 RE526.1 ; v2(157.78,85.8) 157.49,85.8 PR307.1 ; v2(238.66,86.36) 238.77,86.24 RE512.2 RE303.2 ; RE6.1 270.79,87.13 v2(271.26,86.66) 271.69,87.09 CE61.1 ; RE525.2 RE524.2 261.43,85.95 v2(261.44,85.96) RE98.2 CE60.1 ; CE53.1 v2(267.65,100.02) ; RE302.2 RE303.2 ; RE303.2 RE68.2 ; v2(143.66,67.14) 143.64,67.14 143.09,67.69 CZ104.1 ; v2(59.43,118.18) 59.43,119.23 59.97,119.76 PR28.2 ; RC214.1 141.83,79.25 v2(142,79.42) ; RT48.2 24.79,87.45 v2(25.23,87.01) ; v2(158.34,133.88) 158.34,132.55 157.89,132.09 PR418.1
  IN1 w0.381: v2(226.91,58.16) 226.17,57.41 220.43,57.41 220.05,57.03 220.05,56.27 220.37,55.95 v2(221.13,55.95)
  IN1 w0.508: v2(64.49,70.1) 64.49,72.9 v2(63.71,73.67)
  IN2 w0.381: v2(55.09,51.47) 54.15,52.41 50.68,52.41 v2(49.62,53.48)
  IN2 w0.508: v2(43.71,52.21) 43.51,52 41.86,52 40.99,52.87 40.99,59.75 40.09,60.65 v2(38.19,60.65) 39.01,61.48 39.01,63.05 37.77,64.3 37.77,76.49 38.89,77.61 v2(38.89,77.86) ; v2(269.52,80.73) 270.76,80.73 272.41,79.08 272.41,75.52 275.61,72.32 279.12,72.32 279.85,71.58 281.15,71.58 282.58,70.15 282.58,63.5 281.58,62.49 281.58,56.75 278.94,54.11 278.94,53.71 277.98,52.74 277.98,30.74 285.32,23.4 285.32,9.89 288.25,6.96 v2(288.25,4.51) ; v2(143.66,67.14) 143.66,68.36 141.76,70.27 141.76,71.74 137.59,75.91 v2(137.59,78.14) ; v2(25.23,87.01) 26.38,87.01 26.82,87.45 28.6,87.45 29.3,86.75 33.87,86.75 35.84,88.72 v2(36.35,88.72)
  IN3 w0.508: v2(181.25,58.45) 181.89,59.09 181.89,59.97 181.39,60.48 178.16,60.48 177.54,61.1 173.26,61.1 172.24,62.12 171.5,62.12 171,61.62 166.01,61.62 165.56,61.16 162.82,61.16 162.24,61.75 v2(162.24,62.91)
  BOTTOM w0.254: PU200.13 65.7,69.31 65.59,69.2
  BOTTOM w0.305: 207.04,59.01 JKBTP1.15 ; 207.04,59.01 207.04,56.83 207.27,56.59 ; 207.04,59.01 207.04,59.76 v2(207.16,59.88)
  BOTTOM w0.381: PR1235.2 50.07,53.02 v2(49.62,53.48) ; PR413.1 144.68,133.74 v2(144.69,133.75) ; v2(121.64,130.72) 121.69,130.77 UZ35.5 ; PR107.1 180.82,58.02 v2(181.25,58.45) 181.7,58.01 PR113.1 ; PR1259.2 42.77,52.84 43.41,52.21 v2(43.71,52.21)
  BOTTOM w0.457: 65.59,69.2 64.77,69.2 PC206.1 v2(64.49,70.1) 64.48,70.11 PR205.2
  BOTTOM w0.508: 207.27,56.59 207.27,54.86 210.08,52.06 212.51,52.06 214.09,50.48 221.77,50.48 226.21,54.93 226.21,57.25 ; PR417.1 v2(158.34,133.88) ; v2(38.19,60.65) PR1224.2 38.95,60.73 PR1225.1 ; RE532.1 229.82,61.22 227.48,61.22 ; RE505.2 v2(252.63,127.58) ; PR29.1 60.15,119.57 59.43,118.86 v2(59.43,118.18) ; JLED1.6 v2(288.25,4.51) ; v2(241.71,122.5) 242.02,122.5 UE9.8 ; RE74.1 v2(287.78,120.47)
  BOTTOM w1.016: 223.82,66.33 223.82,63.99 226.47,61.35
  vias: v2(67.55,121.87) v2(68.16,121.87) v2(68.77,121.87) v2(152.83,85.63) v2(157.59,114.72) v2(158.18,114.72) v2(165.3,68.67) v2(165.49,69.26) v2(165.81,68.06) v2(165.94,68.67) v2(166.13,69.26) v2(166.44,68.06) v2(166.57,68.67) v2(166.76,69.26) v2(167.04,68.06) v2(167.14,68.69) v2(167.4,69.26) v2(167.73,68.76) v2(168.88,69.29) v2(169.45,69.29) v2(169.45,68.65) v2(223.48,67.2) v2(224.12,67.2) v2(227.49,58.16) v2(252.14,109.56) v2(252.27,112.99) v2(252.78,109.56) v2(252.91,112.99) v2(253.14,110.17) v2(253.41,109.56) v2(253.52,112.99) v2(253.54,75.93) v2(254.13,75.93) v2(260.74,86.71) v2(263.32,90.12) v2(263.32,89.54) v2(263.56,94.52) v2(263.56,93.52) v2(278.92,93.36) v2(278.92,92.66) v2(279.55,93.36) v2(279.55,92.66) v2(280.06,92.97) v2(287.23,125.23) v2(287.23,124.53) v3(163.65,65.75) v3(167.78,67.47)
+3.3V_ALW2: length 95.4
  TOP w0.254: PR104.2 v3(163.57,79.74) 172.49,79.74 176.07,76.16 176.33,76.16 arc(180.14,74.44) 183.67,72.2 arc(188.15,70.32) 192.94,69.48 209.55,69.48 211.25,71.18 v2(211.25,71.54) ; v2(230.47,77.48) 231.18,77.48 232.4,76.26 233.85,76.26 234.84,77.25 237.59,77.25 239.87,74.97 245.23,74.97 RE57.2
  IN3 w0.254: v2(230.47,77.48) 225.02,77.48 219.86,72.32 211.58,72.32 211.25,71.99 v2(211.25,71.54)
+3.3V_ALW_DSW: length 177.8
  TOP w0.381: RC72.2 v2(131.02,82.94) ; 126.05,90.77 127.34,89.48 v2(127.34,86.37)
  TOP w0.508: RC214.2 140.64,80.16 140.46,80.34 CC280.1 CC279.1 138.95,80.35 RC243.2 RC67.2 136.41,80.35 v2(135.98,80.78) ; v2(86.4,125.73) 87.88,127.2 RC241.2
  IN1 w0.508: v2(153.03,124.74) 146.4,124.74 146.31,124.82 139.18,124.82 139.02,124.66 133.3,124.66 132.75,124.1 131.58,124.1 129.69,125.99 124.87,125.99 120.91,129.95 120.34,129.95 117.84,132.45 109,132.45 107.31,134.13 82.11,134.13 v2(81.83,133.85) ; v2(148.13,101.41) 148.13,101.03 146.91,99.8 146.91,94.46 147.22,94.14 v2(147.22,91.97) ; v2(135.98,80.78) 135.98,81.02 134.49,82.51 131.46,82.51 v2(131.02,82.94)
  IN2 w0.508: v2(153.03,124.74) 152.47,124.18 150.74,124.18 147.01,120.45 147.01,118.86 147.55,118.32 148.18,118.32 149.34,117.15 149.34,109.55 149.08,109.29 149.08,106.25 148.87,106.03 148.87,104.71 149.07,104.51 149.07,102.35 v2(148.13,101.41) ; v2(122.65,100.73) 122.66,100.71 v2(122.66,98.24) ; v2(142.78,87.39) 136.36,87.39 134.39,85.42 133.31,85.42 131.02,83.13 v2(131.02,82.94) 127.6,86.37 v2(127.34,86.37)
  IN3 w0.508: v2(147.22,91.97) 147.22,91.53 143.08,87.39 v2(142.78,87.39)
  BOTTOM w0.254: UC1.AJ17 122.66,98.33 v2(122.66,98.24) ; v2(122.65,100.73) 122.62,100.75 122.62,100.89 UC1.AD18
  BOTTOM w0.305: UC1.AD17 122.65,100.83 v2(122.65,100.73)
  BOTTOM w0.508: v2(81.83,133.85) 82.42,133.25 v3(82.42,129.24) 83.53,128.13 84.6,128.13 86.4,126.33 v2(86.4,125.73) ; v2(148.13,101.41) 147.8,101.74 RC323.2
+3.3V_ALW_PCH: length 479.9
  TOP w0.254: v2(150.72,91.42) 151.07,91.06 160.63,91.06 162.1,92.53 164.88,92.53 v3(167.69,89.72) 167.69,85.35 176.38,76.67 arc(180.36,74.84) 184.07,72.5 arc(188.53,70.73) 193.25,69.86 209.4,69.86 210.72,71.18 210.72,71.93 214.59,74.28 217.04,74.28 217.96,73.37 220.15,73.37 arc(223.27,74.66) 224.56,77.78 224.56,78.01 225.8,79.26 225.8,80.73 v2(225.7,80.84) ; RC308.1 136.27,103.06 RC14.2 ; RC187.2 124.3,79.36 126.28,77.38 135.76,77.38 136.47,78.09 v2(136.47,78.45) ; v2(138.31,107.39) 136.16,107.39 RC12.2 134.19,105.42 133.51,105.42 RC23.2
  TOP w0.305: JAPS1.1 v2(264.56,108.96)
  TOP w0.381: RC183.2 RC73.2 ; RC73.2 RC344.2 142.23,83.08 v2(142.29,83.15) ; RC73.2 RC387.2 RC74.2
  TOP w0.457: CC209.1 121.39,102.8 v2(121.39,103.26)
  TOP w0.508: v2(142.8,82.76) 143.1,82.76 144.32,81.54 RC211.1
  TOP w1.016: 147.37,66.25 146.1,67.53 144.94,67.53 141.58,70.89
  IN2 w0.254: v2(225.7,80.84) 226.67,81.81 226.67,87.16 229.74,90.23 229.74,110.02 234.42,114.69 v2(235.63,114.69)
  IN2 w0.381: v2(119.8,99.02) 119.8,101.31 120.61,102.12 120.61,102.48 v2(121.39,103.26)
  IN2 w0.508: v2(152.11,108.55) 152.11,112.09 151.67,112.52 151.67,117.12 v2(153.9,119.34) ; v2(136.46,122.01) 136.41,122.01 135.26,120.86 135.26,120.26 135.88,119.64 135.88,112.08 136.84,111.12 136.84,108.87 138.31,107.39 v2(138.31,107.39) 138.5,107.39 138.87,107.02 v2(138.87,105.24)
  IN3 w0.254: v2(148.31,65.26) 148.31,63.5 154.77,57.03 162.38,57.03 163.44,55.97 178.47,55.97 179.4,56.91 183.79,56.91 184.88,57.99 184.88,58.46 185.28,58.85 195.65,58.85 196.4,58.1 200.7,58.1 204.8,54 210.58,54 211.28,53.3 213.41,53.3 214.1,52.61 218.46,52.61 219.3,53.45 224.49,53.45 225.35,52.59 228.37,52.59 230.63,50.33 247.58,50.33 249.01,51.76 249.01,56.65 248,57.66 248,61.75 251.49,65.24 259.54,65.24 259.99,64.78 261.52,64.78 262.92,66.18 262.92,69.33 263.41,69.82 263.41,73.1 267.66,77.35 277.65,77.35 278.73,78.43 278.73,80.02 278.22,80.53 278.22,82.05 275.17,85.1 275.17,93.14 274.06,94.24 274.06,96 270.34,99.72 270.34,101.95 264.56,107.74 v2(264.56,108.96)
  BOTTOM w0.254: UC1.V19 121.39,103.39 v2(121.39,103.26) ; v2(119.8,99.02) 120.17,98.66 UC1.AJ21 ; v2(264.56,108.96) 263.37,110.15 254.91,110.15 253.67,108.9 251.69,108.9 251.17,109.42 244.17,109.42 238.9,114.69 v2(235.63,114.69) ; v2(122.93,97.28) 123.01,97.36 123.01,97.8 UC1.AK17 ; v2(225.7,80.84) RC222.2
  BOTTOM w0.305: JSPI1.5 166.35,93.91 166.65,93.61
  BOTTOM w0.381: 166.65,93.61 166.65,92.02 165.52,90.89 162.33,90.89 161.85,90.41 158.62,90.41 158.49,90.54 151.6,90.54 v2(150.72,91.42) ; v2(153.9,119.34) 154.34,119.79 UC7.5 ; v2(152.11,108.55) 152.11,107.31 150.64,105.85 148.06,105.85 147.63,105.43 145.43,105.43 v2(145.08,105.07) ; RC347.2 v2(144.11,101.48) RC283.2
  BOTTOM w0.508: v2(146.36,101.65) 146.36,100.99 146.91,100.44 RC330.2 RC331.2 ; RC400.2 v2(138.31,107.39) RC371.2 ; RC17.2 RC15.2 RC25.2 RC348.2 v2(143.79,104.15)
  vias: v2(137.06,78.45) v2(140.69,71.89) v2(140.69,71.31)
+3.3V_ALW_PCH_UZ3: length 6.8
  TOP w1.016: 153.44,59.51 153.44,60.72 152.96,61.2 v3(152.96,62.04) 152.96,62.85 152.17,63.64 151.41,63.64 150.46,64.59
+3.3V_ALW_UE1: length 45
  TOP w0.203: 245.97,87.97 246.26,88.26 247.08,88.26 UE1.B7 ; v2(255.88,89.86) 257.36,89.86 v1(257.66,90.16) 257.8,90.3 CE13.1 ; v2(254.28,84.23) 253.88,84.63 UE1.K2
  TOP w0.254: UE1.M9 v2(255.88,89.86) ; UE1.H1 252.25,83.82 252.25,81.95 ; UE1.G8 v2(251.08,89.86)
  TOP w0.356: CE19.1 251.46,95.41 v2(251.79,95.08)
  TOP w0.381: CE14.1 243.89,87.81 CE23.1 245.81,87.81 245.97,87.97 ; 252.25,81.95 v2(252.22,81.93)
  TOP w0.508: v2(243.25,87.74) 243.83,87.74 CE14.1 ; v2(252.22,81.93) CE15.1 252.22,79.35 RE314.2
  IN2 w0.381: v2(251.08,89.86) 251.08,89.27 250.6,88.78 246.23,88.78 245.18,87.74 v2(243.25,87.74)
  IN2 w0.457: v2(254.28,84.23) 254.28,83.98 v2(252.22,81.93)
  BOTTOM w0.457: 251.25,89.86 252.09,89.01 ; 251.25,89.86 v2(251.08,89.86) ; 251.25,89.86 251.29,89.86 251.79,90.36 v2(251.79,95.08) ; 252.09,89.01 255.04,89.01 v2(255.88,89.86) ; 252.09,89.01 252.09,84.54 252.22,84.42 v2(252.22,81.93)
+3.3V_ALWP: length 29.3
  IN1 w0.254: v2(166.2,76.66) 166.43,76.66 166.7,76.92 166.7,78.88 165.4,80.17 157.72,80.17 v2(157.12,79.58) ; v2(166.2,77.29) 166.32,77.4 166.32,78.7 165.23,79.79 158.04,79.79 157.17,78.93 v2(155.73,78.93)
  BOTTOM w0.254: PR108.2 v2(157.12,79.58) ; v2(155.73,78.93) 155.32,78.93 154.91,78.51 PU100.14
  vias: v2(166.2,76.02) v2(166.2,75.39) v2(166.2,74.75) v3(165.66,78.07)
+3.3V_CAM:
  vias: v1(57.49,128.61) v2(56.7,130.58) v2(56.69,129.98)
+3.3V_EC_PLL: length 1.8
  TOP w0.508: CE17.1 250.02,79.67 250.56,79.13 RE314.1
  vias: v1(250.39,82.26)
+3.3V_HDD_M2:
  vias: v2(26.69,46.37) v2(26.69,45.73) v2(27.33,46.37) v2(27.33,45.73) v2(28.03,46.37) v2(28.03,45.73) v3(12.75,43.83) v3(18.26,43.67) v3(24.84,43.47)
+3.3V_LAN: length 340
  TOP w0.102: 246.66,113.7 v3(246.12,113.7)
  TOP w0.254: v2(208.2,71.77) 207.62,71.18 195.99,71.18 arc(186.59,73.05) 178.62,78.38 177.78,79.22 arc(171.65,88.4) 169.49,99.23 169.49,105.67 164.44,110.73 164.44,114.18 166.15,115.9 v2(166.15,122.16)
  TOP w0.381: RL30.1 RL29.1 254.46,132.21 254.15,131.9 v2(254.15,131.39)
  TOP w0.508: RL5.2 241.15,119.96 RL6.2 241.07,119.89 241.07,118.76 241.64,118.18 v2(242.02,118.18) ; v2(241.03,124.09) 241.03,123.3 RL4.2
  IN1 w0.254: v2(166.15,122.16) 160.95,122.16 158.36,124.75 155.38,124.75 154.77,125.36 146.98,125.36 v2(146.55,125.8)
  IN2 w0.254: v2(146.55,125.8) 145.89,125.8 144.7,124.61 144.7,115.66 145.11,115.25 145.11,109.77 143.25,107.91 143.25,103.23 v2(144.11,102.37) ; 241.17,119.42 v2(232.51,119.42)
  IN2 w0.508: 253.34,129.12 253.34,126.22 251.81,124.7 251.81,114.59 250.29,113.07 250.29,109.75 251.07,108.98 256.44,108.98 257.8,107.62 262.24,107.62 264.82,105.04 267.08,105.04 274.12,98 275.34,98 276.72,96.62 276.72,86.13 277.53,85.32 280.45,85.32 281.9,86.76 281.9,88.66 285.29,92.05 285.29,93.83 JLOM1.9
  IN2 w1.016: 284.58,120.99 284.58,127.54 282.64,129.49 254.1,129.49
  IN3 w0.254: v2(208.2,71.77) 209.13,72.15 210.39,72.15 211.1,72.86 219.73,72.86 224.86,77.99 224.86,78.4 228.9,82.43 228.9,89.11 229.61,89.83 229.61,97.48 230.05,97.92 230.05,110.6 232.51,113.07 v2(232.51,119.42)
  BOTTOM w0.254: RC20.2 143.48,102.88 RC19.2 v2(144.11,102.37) RL70.2
  BOTTOM w0.381: RL1.2 v2(243.8,131.27) 243.8,130.58 RL2.2 ; v2(254.15,131.39) 254.15,133.23 253.77,133.61 CL15.1 253.11,132.78 UL2.5
  BOTTOM w0.508: JLOM1.12 285.38,119.66 v2(284.89,120.15)
  vias: v2(241.67,124.09) v2(246.79,113.36) v2(247.36,113.68) v2(247.36,112.98) v2(284.25,120.15)
+3.3V_LAN_OUT: length 3.4
  TOP w0.203: v2(246.89,129.79) 246.89,128.92 UL1.29 ; UL1.15 v2(250.14,124.53) ; UL1.19 v2(248.39,126.13)
  BOTTOM w0.508: CL29.1 247.14,129.22 247.14,129.54 v2(246.89,129.79)
  vias: v1(245.64,125.26) v2(244.82,121.49) v2(245.45,122.06)
+3.3V_LAN_UZ2: length 1.7
  TOP w0.127: v1(251.4,113.98) 250.24,113.98 249.96,113.7 249.81,113.7
+3.3V_M_TPM: length 9.2
  BOTTOM w0.112: v2(163.17,104.74) v1(163.64,104.27)
  BOTTOM w0.254: UZ12.22 158.33,106.4 158.05,106.12 156.72,106.12 CZ54.1
  BOTTOM w0.381: CZ54.1 156.25,105.65 QZ9.3
  BOTTOM w0.508: QZ9.3 154.6,106.01 154.59,106.01 v2(154.59,106.77) v2(154.59,107.35) 154.59,107.4 153.53,108.46 153.49,108.46 153.49,108.68
  vias: v2(162.72,105.13)
+3.3V_MMI_AUX:
  vias: v1(273.2,70.64)
+3.3V_MMI_IN:
  vias: v2(272.64,59.24) v2(273.07,58.86) v2(273.8,72.97) v2(273.8,72.34) v3(273.01,58.05)
+3.3V_PDA_VOUT: length 2.6
  TOP w0.076: UT5.H2 30.27,83.22 30.27,84.09 30.09,84.27
  TOP w0.112: 30.09,84.27 30.06,84.3
  TOP w0.254: 30.06,84.3 29.95,84.42 29.95,85.08 CT83.1
+3.3V_PGPPB: length 8.4
  TOP w0.381: v2(123.98,99.08) 123.98,99.69 CC265.1 124.37,100.09 125.6,100.09 v1(125.6,100.09) 130.17,100.09 130.64,99.62 RC305.2
  BOTTOM w0.254: v2(123.98,99.08) 124.29,99.39 UC1.AG15
+3.3V_PGPPC: length 17.5
  TOP w0.457: CC207.1 123.33,101.95 v2(123.33,102.43)
  TOP w0.508: v2(134.94,101.26) 134.94,100.74 135.22,100.47 RC306.2
  IN3 w0.457: v2(134.94,101.26) 134.94,102.86 133.93,103.88 125.15,103.88 124.59,103.33 123.9,103.33 123.33,102.75 v2(123.33,102.43)
  BOTTOM w0.076: v2(134.94,101.26) 134.94,100.93 v1(135.1,100.77)
  BOTTOM w0.254: UC1.Y16 123.64,102.74 v2(123.33,102.43)
+3.3V_PGPPD: length 13.1
  TOP w0.508: RC307.2 134.31,100.31 v2(134.31,101.26)
  IN3 w0.457: v2(134.31,101.26) 134.31,102.67 133.68,103.29 125.36,103.29 124.65,102.59 124.65,102.59 124.67,102.58 124.67,102.58 v2(124.68,102.58)
  BOTTOM w0.254: v2(124.68,102.58) 124.41,102.85 UC1.Y15
+3.3V_PGPPE: length 16.4
  TOP w0.127: v2(136.42,104.66) v1(136.42,105.17)
  TOP w0.508: RC308.2 v2(136.42,104.66) ; CC208.1 123.33,103.46 v2(123.33,104.1)
  IN2 w0.254: v2(123.33,104.1) 123.33,104.06 123.93,103.46 130.58,103.46 131.52,104.4 136.17,104.4 v2(136.42,104.66)
  BOTTOM w0.254: v2(123.33,104.1) 123.33,104.21 UC1.T16
+3.3V_RTC_LDO: length 194.2
  TOP w0.508: v2(161.4,73.49) v3(161.4,75.33) 161.4,77.34 159.89,78.85 PR105.2 ; PD3.3 286.55,10.47 286.09,10.93 285.46,10.93 284.89,11.5 284.89,23.33 279.81,28.41 279.81,49.41 277.71,51.51 v2(277.71,53.92)
  IN1 w0.508: v2(212.24,50.53) 224.22,50.53 225.85,52.16 228.61,52.16 229.83,50.95 237.2,50.95 240.08,53.83 v2(241.41,53.83)
  IN2 w0.508: v2(277.71,53.92) 274.46,53.92 272.31,56.07 270.22,56.07 265.93,51.79 252.2,51.79 251.11,52.88 242.36,52.88 v2(241.41,53.83) ; v2(161.4,73.49) 161.4,72.57 163.3,70.67 173.82,70.67 v2(173.96,70.52)
  BOTTOM w0.508: v2(173.96,70.52) 174.52,71.08 176.35,71.08 181.41,66.03 181.41,63.07 181.91,62.56 183.6,62.56 185,63.96 201.13,63.96 202.86,62.23 202.86,59.51 204.14,58.23 204.14,57.4 204.95,56.59 204.95,54.29 205.59,53.66 207.11,53.66 209.55,51.22 211.56,51.22 v2(212.24,50.53)
+3.3V_RUN: length 474.2
  TOP w0.254: RC137.2 85.29,133.17 84.69,132.56 84.69,131.33 85.32,130.69 85.32,128.27 84.23,127.19 79.86,127.19 78.96,126.29 78.96,125.48 v2(78.95,125.47) ; RC282.2 145.96,85.9 v2(145.54,86.32)
  TOP w0.356: v2(55.75,130.92) 55.97,130.71 CA7.1 ; CZ72.1 224.66,55.31 CZ67.1 224.66,56.52 v2(224.62,56.56)
  TOP w0.381: RD8.1 136.68,51.83 138.64,53.8 141.44,53.8 142.45,54.81 144.87,54.81 145.52,55.46 RD6.1 ; 19.01,88.85 18.76,89.1 QV3.5 ; 19.01,88.85 18.76,88.59 QV3.2 ; 19.01,88.85 20.79,88.85 21.04,89.1 v2(21.68,89.1) ; 134.96,118.25 138.14,118.25 139.22,119.33 139.22,122.57 138.25,123.53 135.08,123.53 130.07,128.53 129.06,128.53 126.8,130.79 v2(126.06,130.79) ; 134.96,118.25 134.45,117.74 134.45,115.39 132.49,113.42 132.49,111.49 133.17,110.81 133.17,110.17 RC175.2 RC178.2 133.02,108.98 v2(133.91,108.98) ; 134.96,118.25 134.59,118.62 134.59,119.52 v2(134.59,119.52) ; v2(119.59,133.91) 119.81,133.69 CV85.1 119.81,133.02 120.1,132.73 121.56,132.73 122.01,133.17 v2(122.01,133.91) ; CV81.1 106.2,133.03 RV70.2 105.89,132.17 105.51,131.79 105.51,130.8 v2(105.56,130.74) 105.28,130.74 105.03,130.49 105.03,128.28 105.56,127.75 106.58,127.75 107.09,128.26 RV71.2 ; RC59.2 139.91,83.58 v2(140.36,83.13) 139.91,82.69 RC190.2 ; v2(60.77,125.84) 60.77,130.73 61.49,131.46 RV8.2 ; v2(118.72,128.81) 118.69,128.79 CV83.1 ; RV87.2 115.49,126.87 CV82.1 v2(116.36,126.07) ; RC413.2 134.55,103.76 135.28,103.03 RC287.2 135.28,102.65 135.51,102.42 v2(135.91,102.42)
  TOP w0.457: RC186.2 RC414.2 RC27.2 v2(136.61,82.88) RC13.2 ; PR612.1 43.5,92.53 v2(43.46,92.57) ; RV71.2 108.14,128.4 CV84.1 108.57,127.47 v2(108.73,127.31)
  TOP w0.508: QZ1.3 58.13,124.48 58.44,124.8 v2(58.44,125.86) ; v2(146.76,116.22) 146.76,115.79 147.46,115.09 RC177.2 ; v2(67.92,83.53) 67.92,83.22 68.58,82.56 70.08,82.56 70.51,82.99 73.7,82.99 74.13,82.56 75.91,82.56 77.43,81.04 77.43,73.86 76.25,72.68 74.34,72.68 v2(73.62,71.96) ; RV6.2 50.14,122.12 QV8.3 50.95,124.88 v2(50.95,125.93) ; v2(148.23,109.99) 148.23,110.48 149,111.25 RC176.2 ; RD6.1 RD4.1 146.46,56.59 RD10.1 v2(146.58,55.78) ; v2(214.55,53.35) 213.92,53.99 207.8,53.99 207.16,54.62 207.16,55.13 ; v2(27.58,76.91) 27.37,76.91 25.97,75.51 22.82,75.51 22.06,74.75 19.14,74.75 18.49,75.4 RV18.1 ; v2(239.79,67.31) 240.92,66.18 240.92,65.16 241.57,64.51 243.67,64.51 244.56,65.41 ; v2(118.72,128.81) 118.72,128.17 117.42,126.87 CV82.1
  TOP w3.048: 33.9,67.1 27.46,60.65 27.46,54.11
  IN1 w0.508: v2(142.57,96.21) 142.77,96.21 144,97.45 144,98.65 v2(144.77,99.41) ; v2(156.3,57.96) 155.21,56.87 147.67,56.87 v2(146.58,55.78) ; v2(242.09,72.62) 241.07,72.62 239.98,73.71 239.98,77.55 238.81,78.73 238.81,79.69 237.56,80.94 237.56,83.38 v2(236.75,84.19) ; v2(108.73,127.31) 108.73,124.58 v2(108.21,124.06)
  IN2 w0.508: v2(158.53,116.23) 158.24,115.94 156.04,115.94 154.21,114.11 v2(154.21,111.76)
  IN2 w0.762: v2(140.36,83.13) 140.78,83.13 141.71,82.21 141.71,80.71 140.28,79.28 140.28,75.78 143.94,72.12 143.94,71.08 148.13,66.89 148.88,66.89 149.11,66.66 153.85,66.66 154.15,66.36
  IN2 w1.524: 16.47,97.29 19.71,97.29 21.68,95.32 21.68,91.7
  IN3 w0.508: v2(236.75,84.19) 237.52,84.19 237.96,84.63 237.96,88.09 241.04,91.17 241.04,98.9 242.16,100.02 242.16,107.82 242.01,107.97 242.01,109.1 242.77,109.87 242.77,119.53 v2(240.69,121.61) ; v2(154.21,111.76) 153.17,111.76 148.7,116.23 v2(147.38,116.23) ; v2(247.04,55.76) 247.04,54.94 244.46,52.36 240.47,52.36 239.74,51.64 231.07,51.64 229.1,53.6 226.04,53.6 224.62,55.01 v2(224.62,56.56) ; v2(156.3,57.96) 156.3,64.01 156.79,64.5 v2(156.79,66)
  BOTTOM w0.203: UV7.21 108.38,127.94 108.28,127.84 108.28,127.35 108.32,127.31 v2(108.73,127.31) ; 107.21,132.14 107.81,132.15 108.42,131.54 UV7.30 ; v2(116.36,126.07) 115.93,126.49 115.8,126.49 115.51,126.78 UV7.5 ; 118.52,132.28 118.52,131.84 118.22,131.54 UV7.51 ; UV7.57 118.39,129.14 v2(118.72,128.81)
  BOTTOM w0.254: v2(144.77,99.41) 144.74,99.41 144.74,99.39 RC403.2 ; RV85.2 119.7,128.76 118.78,128.76 v2(118.72,128.81) ; RV85.2 RV95.2 RV93.2 ; RV85.2 RV91.2 ; RC319.2 149.66,110.9 149.66,110.14 150.7,109.1 QC2.2 ; v2(134.59,119.52) 134.59,119.52 134.57,119.54 134.17,119.54 RC272.2 ; v2(133.91,108.98) 133.91,108.72 134.16,108.47 134.5,108.47 RC345.2 ; JEDP1.10 v2(55.75,130.92)
  BOTTOM w0.305: UC8.14 82.79,122.79 CC30.1 84.34,122.79 84.56,122.57 85.29,122.57 85.8,123.08 85.8,123.83 83.31,126.31 79.52,126.31 78.95,125.74 v2(78.95,125.47) ; RV19.2 21.59,91.22 v2(22.31,90.5) ; v2(224.62,56.56) 224.62,56.7 224.45,56.88 JUSH1.19 ; v2(25.61,87.77) 24.98,88.4 RV20.2 ; RC403.2 RC402.2
  BOTTOM w0.381: RC291.2 148.85,116.23 149.1,115.98 UC12.5 ; RC291.2 v2(147.38,116.23) ; RC291.2 148.11,116.39 148.82,117.1 RC225.2 ; 107.21,132.14 105.99,132.14 105.55,131.7 105.55,130.75 v2(105.56,130.74) ; 118.52,132.28 118.97,132.74 RV79.2 119.34,133.42 119.59,133.68 v2(119.59,133.91) ; v2(126.06,130.79) 126.06,131.25 125.75,131.56 125.75,133.24 125.4,133.59 123.34,133.59 123.02,133.91 v2(122.01,133.91) RV81.2 RV83.2 ; RC292.2 139.99,97.74 RC237.2 139.24,97.62 RC267.2
  BOTTOM w0.457: RC278.2 RC292.2 v2(139.99,99.64) ; RE51.1 240.24,121.17 v2(240.69,121.61) 240.24,122.06 RE48.1
  BOTTOM w0.508: v2(224.62,56.56) 224.62,54.24 221.53,51.14 216.76,51.14 v2(214.55,53.35) 214.2,53.71 210.84,53.71 210.34,54.21 210.34,56.46 211.34,57.47 214.1,57.47 216.5,59.87 v2(216.5,62.56) ; v2(67.92,83.53) 67.92,83.23 RD19.2 ; v2(55.75,130.92) 55.75,128.72 55.5,128.47 v2(55.5,125.84) ; v2(108.21,124.06) 108.21,124.63 RV89.2 ; RC51.2 RC189.2 RC47.2 RC50.2 143.51,95.64 142.94,96.21 v2(142.57,96.21) ; RZ362.1 v2(154.21,111.76) ; QV5.2 22.17,90.5 v2(22.31,90.5) ; RC318.2 147.22,107.95 RC279.2 ; RE67.2 236.32,84.62 v2(236.75,84.19) ; v2(158.53,116.23) 158.94,116.64 160.07,116.64 160.58,116.13 RZ89.1
  vias: v2(15.07,97.8) v2(15.07,97.17) v2(15.07,96.53) v2(22.31,89.1) v2(26.63,51.38) v2(26.63,50.75) v2(27.27,51.38) v2(27.27,50.75) v2(27.9,51.38) v2(27.9,50.75) v2(36.03,68.54) v2(36.03,67.91) v2(36.03,67.27) v2(36.66,68.54) v2(36.66,67.91) v2(36.66,67.27) v2(148.23,109.36) v2(154.88,66.58) v2(154.89,66) v2(155.52,66.58) v2(155.52,66) v2(156.15,66.58) v2(156.16,66) v2(156.79,66.58) v2(267.51,76.21) v2(268.1,76.21) v3(36.22,66.08)
+3.3V_RUN_AUDIO: length 0.8
  TOP w0.127: 250.47,69.02 v3(250.47,69.84)
  vias: v2(248.94,67.64) v2(251.15,67.7) v2(261.49,67.6) v2(261.45,67)
+3.3V_RUN_AUDIO_IO: length 4.4
  TOP w0.203: UA1.9 256.33,64.49 CA55.1
  TOP w0.381: CA55.1 255.52,65.82 CA56.1
  TOP w0.508: CA56.1 254.42,66.11 LA12.1
+3.3V_RUN_CARD: length 7.2
  IN2 w1.016: 274.52,60.67 274.52,58.51 276.19,56.84 278.85,56.84
  vias: v2(275.08,61.91) v2(275.08,61.33) v2(279.73,56.72) v2(280.31,56.72) v3(279.16,56.48)
+3.3V_RUN_DIMM1: length 7.7
  TOP w0.254: RD10.2 v1(145.38,57.86) 144.36,58.88 CD27.1 143.42,59.6 CD28.1 143.38,60.06 v2(143.28,60.16)
  BOTTOM w0.254: JDIMM1.255 141.73,61.07 142.63,60.16 v2(143.28,60.16)
+3.3V_RUN_UZ3:
  vias: v3(155.17,63.08)
+3.3V_SPI: length 80
  TOP w0.508: v2(151.47,101.29) 151.4,101.22 RC41.1 ; v2(161.76,94.48) 161.72,94.51 RC31.2 RC30.2 ; v2(152.44,94.69) 149.68,94.69 v3(149.29,94.3) 149.02,94.03 147.53,94.03 146.99,94.58 146.37,94.58 146.03,94.92 146.03,97.18 145.74,97.46 v2(145.36,97.46)
  IN2 w0.508: v2(151.47,101.29) 154.08,101.29 155.52,99.85 155.52,99.25 156.26,98.51 158.14,98.51 158.49,98.87 160.2,98.87 160.7,98.36 160.7,95.53 v2(161.76,94.48)
  IN3 w0.254: v2(123.94,98.29) 124.24,97.99 131.01,97.99 132.7,96.3 134.38,96.3 134.76,95.92 139.26,95.92 140.14,96.8 144.47,96.8 145.14,97.46 v2(145.36,97.46)
  IN3 w0.508: v2(162.17,89.65) 162.17,90.26 161.7,90.74 161.7,94.42 v2(161.76,94.48) ; v2(151.47,101.29) 151.47,95.66 v2(152.44,94.69)
  BOTTOM w0.254: v2(123.94,98.29) 123.64,98.59 UC1.AJ16
  BOTTOM w0.305: JSPI1.6 166.92,94.41 167.22,94.11
  BOTTOM w0.381: 167.22,94.11 167.22,91.79 165.79,90.36 162.88,90.36 v2(162.17,89.65) ; v2(152.44,94.69) 152.38,94.69 151.98,95.09 CC10.1 152.01,95.32 UC5.8 ; v2(151.47,101.29) 151.47,101.48 151.81,101.83 CC9.1 152.64,101.23 UC6.8
+3.3V_TBT: length 48.7
  TOP w0.203: v2(27.09,100.64) UT1.H9
  TOP w0.254: v2(34.12,91.26) 34.31,91.45 34.31,91.76 RT12.2 RT13.2
  TOP w0.381: RT14.2 39.01,95.83 v2(38.57,96.28)
  TOP w0.508: v2(23.95,90.49) 23.46,89.99 RT49.2
  IN2 w0.381: v2(38.57,96.28) 38.57,92.3 37.84,91.58 37.84,90.38 37.41,89.95 34.67,89.95 34.12,90.5 v2(34.12,91.26) 33.76,91.63 32.33,91.63 31.76,91.06 v2(29.79,91.06) 28.84,90.1 27.89,90.1 27.65,89.86 24.57,89.86 v2(23.95,90.49)
  IN2 w0.508: v2(23.95,90.49) 23.65,90.79 23.65,96.66 v2(23.52,96.78)
  BOTTOM w0.254: v2(23.95,90.49) 23.95,91.69 v3(24.09,91.83) 24.47,92.21 24.47,93.66 RT11.2 ; CT43.1 26.8,100.24 27.09,100.53 v2(27.09,100.64) ; v2(29.79,91.06) 30.26,91.06 31.16,91.96 31.16,93.38 31.89,94.11 31.89,94.56 RT337.2
  BOTTOM w0.381: RT14.2 39.01,95.83 v2(38.57,96.28) 39.09,96.8 RT336.2
  vias: v2(23.52,97.42)
+3.3V_TBT_FLASH_R: length 11.8
  TOP w0.254: v2(33.36,91.07) 33.73,90.7 36.97,90.7 37.25,90.42 RT9.1 37.25,89.44 RT2.2 RT3.2 RT4.2 37.03,86.59 RT10.2
  BOTTOM w0.102: v2(33.36,91.07) 33.36,91.51 v1(33.3,91.58)
  BOTTOM w0.254: RT1.2 33.21,89.76 CT1.1 ; CT1.1 33.21,90.54 33.36,90.69 v2(33.36,91.07) ; CT1.1 UT2.8
+3.3V_TBT_LC: length 18.6
  TOP w0.203: UT1.R6 30.66,99.01 v2(31,99.34)
  TOP w0.254: RT9.2 32.26,90.12 v2(32.07,90.31)
  IN2 w0.508: v2(34.57,96.02) 34.06,96.53 34.06,99.22 33.26,100.02 32.28,100.02 31.6,99.34 v2(31,99.34)
  BOTTOM w0.254: v2(31,99.34) CT41.1
  BOTTOM w0.381: v2(32.07,90.31) 32.07,91.81 32.54,92.28 v3(32.54,93.23) 32.54,93.64 33.88,94.98 RT6.2
+3.3V_TBT_S0: length 2.3
  TOP w0.203: v2(30.99,102.58) 30.67,102.26 UT1.R13
  BOTTOM w0.102: v3(19.58,101.36) 19.58,101.23 18.69,100.34 CT68.1
  vias: v2(17.49,101.8) v2(17.49,101.17) v2(17.49,100.53)
+3.3V_TBT_SX: length 29.6
  TOP w0.203: UT1.F8 v2(26.44,99.34)
  TOP w0.254: v2(30.25,92.72) 30.57,92.4 RT18.2 ; RT19.2 v2(31.77,92.47)
  TOP w0.381: RT338.2 37.11,91.64 v2(36.66,91.2)
  IN2 w0.381: v2(31.77,92.47) 32.1,92.8 35.89,92.8 36.66,92.02 v2(36.66,91.2)
  IN2 w0.508: v2(31.77,92.47) 30.5,92.47 v2(30.25,92.72) 29.62,92.09 27.79,92.09 26.99,91.29 26.99,91.16 v2(27.01,91.13) 26.12,91.13 24.6,92.66 24.6,97.8 25.49,98.69 26.08,98.69 26.44,99.04 v2(26.44,99.34)
  BOTTOM w0.102: v1(27.58,90.75) 27.39,90.75 v2(27.01,91.13)
  BOTTOM w0.356: CT42.1 26.44,98.96 v2(26.44,99.34)
  BOTTOM w0.381: RT371.2 36.66,91.44 v2(36.66,91.2) ; v2(27.01,91.13) 26.95,91.13 26.82,91.26 RT372.2 RT16.2
+3.3V_TBTA_FLASH: length 69.8
  TOP w0.203: CT84.1 30.89,85.55 30.89,85.18 31.16,84.9 31.16,84.16 31.02,84.02 UT5.G1
  TOP w0.381: v2(29.87,69.56) CT70.1 ; CT70.1 29.23,70.48 RT50.2 RT52.2 ; CT70.1 27.99,69.56 RT51.2 ; 27.96,73.34 v2(27.96,73.37) ; 27.96,73.34 28.54,73.34 RT98.2 ; 27.96,73.34 27.96,73.29 27.98,73.28 RT53.2 ; RT95.2 v2(27.19,86.62) ; v2(30.5,87.96) 30.5,86.82 CT84.1
  TOP w0.508: RT66.2 RT67.2 37.62,83.91 37.11,84.42 v2(36.5,84.42) 36.5,84.86 RT10.1
  IN1 w0.254: v2(30.5,87.96) 30.5,87.7 29.42,86.62 v2(27.19,86.62)
  IN2 w0.508: 29.49,72.65 28.78,73.37 v2(27.96,73.37) ; 29.49,72.65 29.55,72.59 30.31,72.59 31.14,73.42 33.17,73.42 35.18,75.42 35.18,82.38 ; 29.49,72.65 29.49,69.94 v2(29.87,69.56) ; v2(27.19,86.62) 26.77,86.21 26.77,85.05 27.2,84.62 29.03,84.62 30.4,83.25 33.53,83.25 34.39,82.38 35.18,82.38 ; 35.18,82.38 35.18,83.68 35.91,84.42 v2(36.5,84.42)
  BOTTOM w0.254: RT76.2 26.59,83.5 26.59,86.03 v2(27.19,86.62) ; RT107.2 33.62,83.83 34,84.21 34.7,84.21 v1(35.14,83.77) 35.85,83.77 v2(36.5,84.42) ; RT106.2 29.55,87.26 29.28,87.53 29.28,88.26 29.55,88.53 30.31,88.53 30.5,88.34 v2(30.5,87.96)
  BOTTOM w0.305: JDB1.1 30.38,67.23 31.14,67.99 31.14,68.59
  BOTTOM w0.508: v2(29.87,69.56) 30.17,69.56 31.14,68.59 UT6.8
+3.3V_TP: length 20.2
  TOP w0.381: RZ116.1 214.08,54.95 RZ20.1 v2(213.45,54.94) 213.16,54.65 v1(211.68,54.65) 208.09,54.65 207.86,54.87 207.86,56.08 ; v2(215.72,53.33) 215.72,53.66 216.76,54.7 RZ21.1 216.75,54.95 RZ117.1 ; RZ19.1 212.19,59.44 v2(211.78,59.85)
  BOTTOM w0.305: v2(209.82,59.84) 210.05,59.61 JKBTP1.9
  BOTTOM w0.381: v2(215.72,53.33) 214.11,54.94 v2(213.45,54.94)
  BOTTOM w0.508: v2(209.82,59.84) 209.82,60.34 210.28,60.8 211.42,60.8 211.78,60.44 v2(211.78,59.85)
+3.3V_TSP: length 5.2
  TOP w0.508: CV19.1 50.89,129.54 v3(50.89,128.6) 50.89,128.28 49.17,126.57 QV8.1
  BOTTOM w0.254: JEDP1.1 51.25,131.88 v2(51.08,131.71)
+3.3V_VCCHDA: length 19
  TOP w0.127: v3(121.68,97.78) 121.68,97.9 v2(122.01,98.24)
  TOP w0.254: v2(122.01,98.24) 122.01,98.42 122.41,98.82 CC313.1 ; LC1.2 137.29,97.62 137.11,97.43 CC324.1 135.8,97.43 v2(135.74,97.37)
  IN2 w0.254: v2(122.01,98.24) 122.01,98.09 122.36,97.74 124.13,97.74 124.37,97.98 131,97.98 131.71,97.27 135.63,97.27 v2(135.74,97.37)
  BOTTOM w0.254: UC1.AJ19 v2(122.01,98.24)
+3.3V_VDD_DCIN: length 103.3
  TOP w0.508: v2(38.76,56.91) 38.75,56.89 PR1206.1 PR1208.1 ; 55.19,116.42 54.63,116.98 54.63,117.98 v2(54.24,118.37) ; 55.19,116.42 58.1,116.42 58.64,116.96 62.23,116.96 62.85,117.57 v2(63.59,117.57) ; 55.19,116.42 PC9.1 PR17.1
  IN2 w0.508: v2(46.61,96.78) 46.61,97.37 45.69,98.28 45.41,98.28 44.88,98.82 44.88,106.59 46.76,108.47 46.76,111.72 47.38,112.34 47.38,116.37 48.63,117.63 53.49,117.63 v2(54.24,118.37)
  IN3 w0.508: v2(38.76,56.91) 39.71,57.86 39.71,63.4 38.67,64.44 38.67,76.12 40.37,77.82 40.37,79.48 44.15,83.27 44.15,87.51 46.06,89.42 46.06,91.51 47.31,92.76 47.31,96.43 46.95,96.78 v2(46.61,96.78)
  BOTTOM w0.381: PR27.2 v3(56.78,118.69) 56.78,118.13 56.3,117.65 54.96,117.65 v2(54.24,118.37) 54.24,118.8 54.56,119.12 54.56,120.8 54.18,121.18 PU1.5
  BOTTOM w0.508: v2(38.76,56.91) 39.08,56.91 39.46,57.29 PD1801.3 ; v2(63.59,117.57) PC10.1 63.98,118.24 64.2,118.02 PU2.3
+3.3V_VDD_PIC: length 141.7
  TOP w0.254: PR1240.1 PR1254.2 34.36,58.48 34.94,59.05 v3(37.54,59.05) 38.07,59.05 v2(38.12,59) 38.12,58.56 37.5,57.94 PR1237.1 ; v2(31.85,125.33) PR1236.2 ; PR1253.1 v2(45.57,99.26)
  IN1 w0.254: v2(38.12,59) 38.12,59.51 37.3,60.34 36.47,60.34 35.77,61.03 35.77,62.49 35.27,63 v2(34.82,63)
  IN2 w0.254: v2(38.12,59) 38.12,59.76 37.25,60.64 37.25,76.86 v2(37.74,77.35) ; v2(27.05,112.43) 27.74,112.43 28.35,113.04 28.35,123.45 30.22,125.33 v2(31.85,125.33)
  IN2 w0.381: v2(24.23,65.9) 30.34,65.9 33.23,63 v2(34.82,63)
  BOTTOM w0.254: 43.14,99.26 43.1,99.26 41.88,98.04 41.88,93.61 41.12,92.85 38.7,92.85 37.93,92.09 37.93,90.43 36.96,89.46 36.96,86.06 36.85,85.95 ; 43.14,99.26 42.66,99.74 42.66,102.68 PR1214.1 41.96,102.77 41.96,102.35 41.55,101.94 39.78,101.94 38.03,103.7 36.8,103.7 36.35,104.15 36.35,107.03 34.9,108.48 27.04,108.48 25.91,109.61 25.91,111.29 v2(27.05,112.43) ; 43.14,99.26 v2(45.57,99.26) ; v2(30.73,89.33) 31.5,89.33 32.88,87.95 32.88,86.67 33.6,85.95 36.85,85.95 ; 36.85,85.95 36.85,84.9 37.05,84.7 37.05,77.66 37.36,77.35 v2(37.74,77.35) 39.2,77.35 41.1,79.25 41.1,80.84 40.9,81.04 QT1.2 ; PC1204.1 35.06,63.68 35.61,63.13 PU1200.5 ; PC1204.1 35.06,64.21 35.44,64.59 PR1226.1 ; PC1204.1 34.82,63.46 v2(34.82,63) ; PD1801.2 39.41,59 v2(38.12,59)
  BOTTOM w0.381: QT1.5 QT1.2
+3.3V_VDD_PIC_PDA: length 12.7
  TOP w0.203: v2(34.48,85.42) 34.46,85.4 34.46,84.64 33.52,83.7 UT5.B1 ; UT5.H1 30.52,84.5 v2(30.43,84.59)
  TOP w0.381: v2(34.48,85.42) 34.66,85.42 35,85.76 35,87.13 CT74.1
  IN2 w0.381: v2(30.43,84.59) 31.06,83.96 33.49,83.96 34.48,84.95 v2(34.48,85.42)
  BOTTOM w0.112: v1(35.97,85.04) 35.58,85.42 v2(34.48,85.42)
+3.3V_WLAN: length 19.5
  BOTTOM w2.032: 242.24,100.57 241.35,99.68 241.35,90.33 240.84,89.83 240.84,87.72 240.51,87.39 240.51,85.38 240.87,85.02 240.87,81.93
  vias: v2(241.63,61.73) v2(242.21,62.37) v2(242.21,61.73) v2(242.37,80.78) v2(242.37,80.2) v2(242.37,79.59) v2(243.57,101.83) v2(243.57,101.19) v2(244.21,101.83) v2(244.21,101.19) v3(243.15,104.44) v3(243.15,102.5) v3(243.43,106.32)
+3.3V_WLAN_UZ2: length 2.3
  TOP w0.127: 249.02,108.77 246.91,108.77 v1(246.76,108.62)
+3.3V_WWAN: length 7.2
  BOTTOM w2.54: 270.86,103.63 270.86,100.39 273.63,97.62
  vias: v2(236.76,94.95) v2(236.76,94.35) v2(236.76,93.76) v2(237.7,112.47) v2(238.09,112.91) v2(238.34,108.34) v2(238.34,107.71) v2(238.47,112.47) v2(238.66,108.85) v2(239.04,108.34) v2(239.04,107.71) v2(275.04,97.17) v2(275.04,96.53) v2(275.04,95.9) v2(275.04,95.26) v2(275.04,94.63) v3(237.62,106.28)
+3.3V_WWAN_UZ4: length 2.3
  TOP w0.127: v3(273.57,92.52) 273.89,92.84 275.78,92.84
+5V_ALW: length 326.8
  TOP w0.203: 280.44,90.12 280.44,90.71 280.15,91.01 279.55,91.01 279.49,90.94 UZ4.4 ; v2(159.41,60.04) 159.29,60.04 159,60.34 UZ3.4 ; UZ5.4 244.81,63.83 244.57,63.6 v2(243.86,63.6) ; UZ2.4 253.01,111.2 v2(253.2,111.39)
  TOP w0.254: UZ8.4 205.66,50.89 205.54,50.76 203.4,50.76 v3(201.64,52.53) 200.72,53.44 v2(200.72,54.2)
  TOP w0.305: UZ21.3 126.83,128.78 127.16,129.12 v2(127.28,129.12) ; v2(127.09,131.46) 125.12,131.46 124.61,130.95 124.61,129.68 123.98,129.04 122.73,129.04 122.44,128.76 UZ19.3 ; 138.2,65.54 137.69,66.05 137.44,66.05 137.19,66.3 UZ26.3
  TOP w0.381: PR602.2 43.53,96.59 42.82,95.88 42.82,92.04 43.08,91.78 43.69,91.78 44.19,91.27 v2(44.19,90.87) ; v2(225.26,56.59) 225.28,56.56 CZ64.1 225.28,55.56 CZ69.1
  TOP w0.457: PC685.1 62.69,114.9 62.94,114.64 v2(62.94,114.63)
  TOP w0.508: 138.2,65.54 141.78,65.54 v3(142.06,65.26) v2(143.2,64.12) ; v2(32.63,125.33) 32.63,125.7 33.13,126.21 PR7.1 ; v2(248.5,58.18) RA53.2 ; v2(60.22,95.07) 60.15,94.99 PC677.1 ; LED3.2 v2(294.47,127.59)
  IN1 w0.508: v2(44.19,90.87) 45.13,90.87 46.28,92.01 52.07,92.01 52.45,91.63 v2(52.45,91.27) ; v2(159.41,60.04) 159.07,60.04 158.16,60.95 152.62,60.95 152.17,61.4 146.82,61.4 144.11,64.12 v2(143.2,64.12) ; v2(62.94,114.63) 62.44,114.63 61.77,113.96 61.77,112.11 v2(60.67,111.01)
  IN2 w0.508: v2(43.27,63.64) 43.27,63.96 39.8,67.42 39.8,75.64 43.56,79.4 43.56,88.7 44.19,89.33 v2(44.19,90.87) ; 255.88,111.05 255.88,110.56 258.12,108.32 262.41,108.32 265.07,105.65 267.33,105.65 274.37,98.61 275.59,98.61 277.33,96.87 277.33,90.18 v2(278.34,89.16) ; 255.88,111.05 253.54,111.05 v2(253.2,111.39) ; 255.88,111.05 255.88,113.68 253.03,116.52 253.03,123.37 257.85,128.18 282.51,128.18 283.55,127.14 283.55,119.9 284.01,119.44 290.88,119.44 294.47,123.03 v2(294.47,127.59) ; v2(279.14,53.03) 278.64,52.53 278.64,31.1 285.98,23.76 285.98,10.48 287.04,9.41 v2(288.76,9.41) ; v2(62.38,63.96) 59.9,63.96 59.33,64.53 59.33,70.24 59.28,70.29 59.28,77.7 57.19,79.8 57.19,81.68 59.21,83.7 59.21,86.27 58.63,86.84 58.63,94.05 59.65,95.07 v2(60.22,95.07) 60.22,102.56 60.5,102.84 60.5,107.05 59.71,107.83 59.71,110.06 v2(60.67,111.01)
  BOTTOM w0.203: 59.61,110.31 59.22,109.92 PU610.2 ; PU612.2 60.5,94.8 v2(60.22,95.07)
  BOTTOM w0.254: PU614.6 62.87,114.56 v2(62.94,114.63)
  BOTTOM w0.305: JUSH1.18 224.95,57.06 225.26,56.75 v2(225.26,56.59)
  BOTTOM w0.508: DT1.2 v2(22.95,69.16) ; JUART1.1 v2(128.81,133.23) ; v2(288.76,9.41) 288.76,8.77 289.03,8.51 JLED1.1 ; 59.61,110.31 PC661.1 60.15,110.48 60.67,111 v2(60.67,111.01)
  vias: v2(18.25,52.65) v2(18.25,52.02) v2(18.88,52.65) v2(18.88,52.02) v2(20.41,76.85) v2(20.41,76.21) v2(20.41,75.58) v2(21.04,76.85) v2(21.04,76.21) v2(21.04,75.58) v2(73.05,134.5) v2(73.68,134.5) v2(74.32,134.5) v2(85.24,135.39) v2(85.88,135.39) v2(86.51,135.39) v2(146.7,128.78) v2(146.7,128.14) v2(162.63,127.48) v2(162.63,126.85) v2(200.15,57.14) v2(200.15,56.55) v2(200.15,55.97) v2(200.15,55.38) v2(200.15,54.8) v2(200.16,54.23) v2(200.73,56.55) v2(200.73,55.97) v2(200.73,55.38) v2(200.73,54.8) v2(201.32,54.51) v2(275.18,74.53) v2(276.19,79.61) v2(276.82,79.61) v2(277.46,79.61) v2(278.09,79.61) v2(279.49,89.23) v2(279.49,88.59) v2(280.12,89.55) v2(280.12,88.91)
+5V_ALW2: length 3
  TOP w0.127: v2(185.96,58.04) v3(185.96,58.63)
  TOP w0.254: v2(185.96,58.04) 185.44,58.04 185.13,57.73 PC126.1
  BOTTOM w0.254: v2(185.96,58.04) 185.84,57.91 PU102.15
+5V_ALW_PDA: length 5.3
  TOP w0.203: v2(30.05,79.51) 30.52,79.04 UT5.H10
  IN1 w0.508: v2(33.51,77.47) 33.5,77.47 32.54,78.43 30.63,78.43 30.05,79.02 v2(30.05,79.51)
  vias: v1(34.03,74.81) v2(33.51,76.83) v2(33.51,76.2) v2(34.15,77.47) v2(34.15,76.83) v2(34.15,76.2)
+5V_ALWP: length 37.9
  BOTTOM w0.254: PU102.14 185.39,58.28 185.64,58.53 186.69,58.53 189.15,61 198.98,61 199.49,60.49 199.49,58.66 199.17,58.34 PC120.1 ; 198.86,57.72 199.34,57.72 199.95,58.33 199.95,60.67 199.16,61.45 189.1,61.45 187.48,59.83 186.82,59.83 PR117.2
  vias: v2(197.14,56.38) v2(197.14,55.79) v2(197.14,55.21) v2(197.14,54.63) v2(197.73,56.38) v2(197.73,55.79) v2(197.73,55.21) v2(197.73,54.63) v2(198.31,56.38) v2(198.31,55.79) v2(198.31,55.21) v2(198.31,54.63) v3(196.39,54.54)
+5V_PD_VDD: length 6.6
  BOTTOM w0.102: DT2.1 18.25,70.94 v3(17.74,70.43)
  BOTTOM w0.508: UT7.1 19.97,68.53 DT1.1 ; DT1.1 DT2.1 ; DT1.1 v2(20.5,69.16)
+5V_RUN: length 137
  TOP w0.356: v2(206.54,57.83) 206.51,57.86 CZ92.1
  TOP w0.381: CZ71.1 223.46,55.5 CZ66.1 223.46,56.21 223.83,56.59 v2(223.99,56.59)
  IN1 w0.508: v2(242.11,60.51) v2(241.48,60.51) v2(240.89,60.51) v2(240.31,60.51) 240.31,58.43 239.36,57.48 237.39,57.48 234.75,54.84 233.45,54.84 233,54.39 224.79,54.39 223.99,55.19 v2(223.99,56.59) 223.94,56.59 222.27,54.93 218.65,54.93 217.78,55.8 214.04,55.8 213.24,56.61 210.61,56.61 210.25,56.25 208.13,56.25 v2(206.54,57.83)
  IN2 w1.016: 17.65,72.24 17.65,73.24 16.35,74.55 14.82,74.55 14.11,75.27 14.11,79.55 16.9,82.35 16.9,90.34 ; 239.61,117.36 240.99,115.97 240.99,113.36 242.65,111.71 244.04,111.71 247.64,108.11 255.74,108.11 257.28,106.58 261.66,106.58 264.44,103.8 265.2,103.8 273.26,95.73 273.26,89.79 273.82,89.23 ; 25.17,67.19 25.49,66.88 32.03,66.88 33.68,65.23
  IN3 w1.016: 22.31,68.4 21.8,68.91 21.8,70.37 20.85,71.32 18.38,71.32
  BOTTOM w0.305: JUSH1.20 223.95,56.63 v2(223.99,56.59) ; JKBTP1.16 206.55,57.97 206.54,57.96 v2(206.54,57.83)
  vias: v2(17.51,71.64) v2(17.5,71.06) v2(17.97,90.81) v2(18.54,90.79) v2(23.14,68.15) v2(23.77,68.15) v2(34.95,65.1) v2(35.58,65.1) v2(238.34,118.06) v2(239.04,118.06) v2(273.9,86.75) v2(273.9,86.12) v2(274.47,87.07) v2(274.47,86.43) v2(274.47,85.8) v2(274.47,85.16) v3(243.61,61.75)
+5V_RUN_AUDIO:
  vias: v2(247.52,59.68) v2(247.52,59.09) v2(247.52,58.52) v2(247.52,57.95) v2(264.21,65.34) v2(264.21,64.53) v2(264.62,64.93) v2(265.05,65.31) v3(248.49,56.27)
+5V_RUN_AUDIO_UZ5:
  vias: v1(248,61.58)
+5V_RUN_PVDD_L:
  vias: v1(261.54,59.47) v2(264.44,63.05) v2(264.36,59.6) v2(264.36,59.02) v2(265.81,63.05)
+5V_RUN_UZ4:
  vias: v1(278.1,87.97)
+5V_TBT_VBUS: length 4.8
  BOTTOM w0.127: CT93.1 v3(23.33,70.97)
  BOTTOM w0.254: DT2.2 DT3.1 22.74,72.72 CT93.1
+5V_TBTA_VBUS_D: length 3.9
  BOTTOM w0.127: DT3.2 v1(19.33,74.06)
  BOTTOM w0.254: DT3.2 18.22,72.72 17.99,72.49 UT8.3
+5V_USB_CHG_PWR:
  vias: v2(278.03,73.16) v2(278.66,73.16) v2(280.38,72.85) v2(281.01,72.85) v2(282.28,74.31) v2(282.28,73.67) v3(279.45,72.32)
+DV33_18:
  vias: v1(278.57,63.21)
+GND_CHASSIS: length 16.3
  TOP w0.508: v2(261.26,121.02) RL18.2 RL17.2 262.55,119.98 v3(265.86,119.98) RL16.2 RL15.2
  IN1 w0.508: v2(261.26,121.02) v2(257.22,121.02)
  BOTTOM w0.508: v2(257.22,121.02) 256.47,120.26 CL22.2
+VBUS_DC_SS: length 64.5
  IN2 w0.508: v2(57.55,102.8) 57.55,98.64 58.3,97.89 58.3,95.62 57.3,94.61 57.3,86.11 54.99,83.8 54.99,71.92 56.35,70.56 57.06,70.56 58.11,69.51 58.11,64.88 56.36,63.13 46.95,63.13 v2(45.43,61.61)
  BOTTOM w0.508: v2(52.67,103.26) v1(53.29,102.63) 53.76,102.17 56.92,102.17 v2(57.55,102.8) ; PD903.2 46.51,59.26 45.43,60.34 v2(45.43,61.61)
  vias: v2(52.06,105.8) v2(52.06,105.17) v2(52.06,104.53) v2(52.06,103.9) v2(52.06,103.26) v2(52.67,105.8) v2(52.67,105.17) v2(52.67,104.53) v2(52.67,103.9)
+VCC1V8A_TBTA_LDO: length 3.8
  TOP w0.203: 28.15,84.53 28.42,84.26 28.73,84.26 UT5.K1
  TOP w0.457: v2(27.51,85.35) 27.77,85.09 CT73.1
  TOP w0.508: 28.15,84.53 CT73.1
  BOTTOM w0.127: v1(27.02,85.76) 27.43,85.35 v2(27.51,85.35)
+VCC1V8D_TBTA_LDO: length 15
  TOP w0.203: v2(34.49,83.15) 34.19,83.15 UT5.A2
  TOP w0.381: RT97.1 32.16,73.29 35.1,76.24 35.1,77.73 34.71,78.13 v2(34.49,78.13) ; v2(34.49,83.15) 35.3,83.15 CT72.1
  BOTTOM w0.381: v2(34.49,78.13) 35.09,78.13 35.65,78.69 v1(35.65,79.79) 35.65,81.99 v2(34.49,83.15)
+VCC3V3_ANA_PCIE: length 1.5
  TOP w0.203: UT1.L16 v2(28.39,103.89)
  BOTTOM w0.254: CT63.1 27.82,104.45 v2(28.39,103.89)
+VCC3V3_ANA_USB2: length 1.1
  TOP w0.203: v2(28.39,103.24) 28.39,103.25 28.08,103.56 UT1.J16
  BOTTOM w0.254: v2(28.39,103.24) 28.25,103.38 CT64.1
+VCC_1P8: length 23.3
  TOP w0.127: v2(138.52,102.44) v1(137.87,102.44)
  TOP w0.457: v2(126.34,104.81) 126.34,104.52 126.71,104.15 CC222.1
  IN3 w0.254: 131.23,104.36 126.64,104.36 126.34,104.66 v2(126.34,104.81) 126.34,105.01 126.67,105.34 131.18,105.34 131.47,105.05 131.47,104.6 131.23,104.36
  IN3 w0.508: v2(138.52,102.44) 137.55,103.41 136.25,103.41 134.81,104.85 131.47,104.85
  BOTTOM w0.254: v2(126.34,104.81) 126.43,104.72 UC1.U11 UC1.U12
  BOTTOM w0.508: v2(138.52,102.44) 138.12,102.04 RC313.2
+VCC_CORE: length 51.4
  TOP w0.305: v2(109.98,113.73) 109.45,114.26 109.45,117.64 109.17,117.92 RC140.2 ; PC1050.1 114.49,109.43 114.68,109.62 v2(114.69,109.62)
  TOP w0.508: PC1013.1 v2(84.23,106.44) ; PC1011.1 v2(87.84,106.44) ; PC1064.1 v2(89.05,106.44) ; PC1075.1 v2(86.64,106.44) ; PC1072.1 v2(85.43,106.44)
  BOTTOM w0.127: 109.64,108.68 UC1.K40 ; UC1.K40 109.33,108.36 ; UC1.K40 109.64,107.97 ; 108.86,108.83 UC1.J40 ; UC1.J40 109.18,108.52 ; UC1.J40 109.18,109.16 ; UC1.J40 109.49,108.83 ; 112.84,108.5 UC1.J33 ; UC1.J33 112.84,109.13 ; UC1.J33 112.49,108.83 ; UC1.J33 113.14,108.83 ; 113.29,97.63 UC1.AK33 ; UC1.AK33 113.29,98.34 ; UC1.AK33 113.63,97.99 ; UC1.AK33 112.99,97.99 ; UC1.J37 110.68,108.83 ; UC1.J37 111.01,109.16 ; UC1.J37 111.31,108.83 ; UC1.J37 111.01,108.52 ; UC1.K33 112.99,108.36 ; UC1.K33 113.29,107.92 ; UC1.K33 113.29,108.69 ; 107.81,107.94 107.81,107.95 UC1.K43 107.81,108.69 ; UC1.K42 108.72,108.69 108.67,108.74 ; UC1.K42 108.72,107.98 ; UC1.K42 109.03,108.36 ; UC1.AL40 109.77,97.53 109.77,97.53 ; UC1.AL40 110.42,97.53 110.42,97.53 ; UC1.AL40 110.09,97.2 ; UC1.AL40 110.09,97.88 ; UC1.K37 111.16,108.36 ; UC1.K37 111.47,108.66 ; UC1.K37 111.47,108.02 ; 111.52,98.32 111.52,98.05 UC1.AK37 ; UC1.AK37 111.5,97.96 111.85,97.96 ; UC1.AK37 111.47,97.64 111.47,97.63 ; 112.38,107.97 UC1.K35 ; UC1.K35 112.38,108.69 ; UC1.K35 112.69,108.36 ; UC1.AL33 113.75,97.87 ; UC1.AL33 114.06,97.53 ; UC1.AL33 113.75,97.2 ; UC1.AL33 113.41,97.53 ; 112.38,98.34 UC1.AK35 ; UC1.AK35 112.69,97.99 ; UC1.AK35 112.04,97.99 ; UC1.AK35 112.38,97.66 ; UC1.AL37 111.92,97.18 111.93,97.17 ; UC1.AL37 111.92,97.83 111.93,97.83 ; UC1.AL37 111.6,97.53 111.6,97.53 ; UC1.AL37 112.23,97.53 ; 110.55,98.4 UC1.AK38 ; UC1.AK38 110.23,97.99 ; UC1.AK38 110.55,97.65 110.55,97.65 ; UC1.AK40 109.64,98.37 ; UC1.AK40 109.95,97.99 ; UC1.AK40 109.33,97.99 ; UC1.AK40 109.64,97.64 ; 110.55,108 UC1.K38 ; UC1.K38 110.55,108.68 ; UC1.K38 110.86,108.36 ; 114.67,109.12 UC1.J30 114.36,108.83
  BOTTOM w0.203: v2(112.22,113.7) UC1.A34 ; v2(107.29,113.96) 107.26,113.93 UC1.A44 ; UC1.A30 114.7,113.45 v2(114.45,113.7) ; UC1.A39 109.74,113.49 v2(109.98,113.73)
  BOTTOM w0.254: UC1.AM38 v2(111.01,96.66) UC1.AM37 v2(111.92,96.66) UC1.AM35 ; UC1.G42 108.97,109.54 v2(109.17,109.54) 109.39,109.54 UC1.G40 ; UC1.G35 112.59,109.5 v2(112.83,109.5) 113.09,109.5 UC1.G33 ; UC1.G37 111.22,109.54 v2(111,109.54) 110.8,109.54 UC1.G38 ; UC1.G30 114.79,109.62 v2(114.69,109.62) 114.54,109.62 UC1.G32
  BOTTOM w0.508: PC1010.1 v2(81.81,109.29) ; PC1070.1 v2(81.81,106.44) ; PC1009.1 v2(83.02,109.29) ; PC1072.1 v2(85.43,106.44) ; PC1006.1 v2(83.02,106.44) ; PC1069.1 v2(80.61,106.44) ; PC1075.1 v2(86.64,106.44) ; PC1174.1 v2(86.64,109.29) ; PC1071.1 v2(80.61,109.29) ; PC1172.1 v2(84.23,109.29) ; PC1013.1 v2(84.23,106.44) ; PC1173.1 v2(85.43,109.29)
  vias: v2(71.33,108.47) v2(71.33,107.83) v2(71.33,107.2) v2(71.33,106.56) v2(71.33,105.93) v2(72.03,108.47) v2(72.03,107.83) v2(72.03,107.2) v2(72.03,106.56) v2(72.03,105.93) v2(73.81,111.52) v2(75.02,111.52) v2(75.14,106.75) v2(75.14,106.12) v2(75.75,106.75) v2(75.75,106.12) v2(76.22,111.52) v2(76.35,109.93) v2(76.35,109.29) v2(76.35,108.66) v2(76.35,108.02) v2(76.35,107.39) v2(76.35,106.75) v2(76.99,109.93) v2(76.99,109.29) v2(76.99,108.66) v2(76.99,108.02) v2(76.99,107.39) v2(76.99,106.75) v2(108.48,105.48) v2(108.48,103.07) v2(108.48,100.66) v2(108.91,99.02) v2(109.18,108.14) v2(109.18,107.28) v2(109.55,99.02) v2(109.63,107.71) v2(109.75,105.48) v2(109.75,103.07) v2(109.75,100.66) v2(110.09,107.28) v2(110.54,107.71) v2(110.77,99.02) v2(111.01,108.14) v2(111.01,107.28) v2(111.02,105.48) v2(111.02,103.07) v2(111.02,100.66) v2(111.45,107.71) v2(111.5,99.02) v2(111.92,107.28) v2(111.91,98.32) v2(112.29,105.48) v2(112.29,103.07) v2(112.29,100.66) v2(112.34,99.02) v2(112.39,107.71) v2(112.84,108.14) v2(112.84,98.32) v2(112.85,107.28) v2(113.31,107.71) v2(113.56,105.48) v2(113.56,103.07) v2(113.56,100.66) v2(113.77,107.28) v3(70.76,104.66)
+VCC_CORE_G0: length 1.2
  TOP w0.254: v2(114.62,108.07) 114.22,108.47 T122.1
  BOTTOM w0.254: UC1.K32 114.33,108.36 v2(114.62,108.07)
+VCC_CORE_G1: length 2.2
  TOP w0.254: T123.1 114.11,98.35 114.22,98.46 v2(114.22,99.05)
  BOTTOM w0.254: UC1.AK32 114.21,98.83 114.22,98.84 v2(114.22,99.05)
+VCC_GT: length 34.3
  BOTTOM w0.127: 97.27,106.25 UC1.N63 ; UC1.N63 96.69,106.25 ; UC1.N63 96.99,106.56 ; UC1.N63 96.99,105.91 ; UC1.K56 100.8,108.36 ; UC1.K56 100.49,108 ; UC1.K56 100.19,108.36 ; UC1.K56 100.49,108.7 ; 104.15,108.67 UC1.K50 ; UC1.K50 103.85,108.36 ; UC1.K50 104.46,108.36 ; UC1.K50 104.15,108.05 ; 97.77,106.71 UC1.M62 ; UC1.M62 97.46,107.02 ; UC1.M62 97.17,106.71 ; UC1.M62 97.46,106.44 ; 99.46,108.83 99.45,108.83 UC1.J58 ; UC1.J48 104.26,108.83 104.26,108.83 ; UC1.J48 104.61,108.52 ; UC1.J48 104.96,108.83 104.97,108.83 ; 103.24,108.7 UC1.K52 ; UC1.K52 103.54,108.36 ; UC1.K52 103.24,107.97 ; 99.69,108.83 99.69,108.83 UC1.J56 ; UC1.J58 98.79,108.83 98.76,108.8 ; UC1.J58 99.12,108.52 ; 102.27,108.83 UC1.J53 ; UC1.J53 101.86,108.52 ; UC1.J53 101.56,108.83 ; 100.58,108.83 UC1.J55 ; UC1.J55 101.32,108.83 ; UC1.J55 100.95,108.52 ; UC1.J45 106.79,108.83 ; UC1.J45 106.44,108.52 ; UC1.J45 106.09,108.83 106.09,108.83 ; UC1.J52 102.43,108.83 ; UC1.J52 102.78,108.52 ; UC1.J52 103.14,108.83 ; 107.05,108.83 UC1.J43 107.35,108.46 ; 98.36,108.36 UC1.K60 ; UC1.K60 98.97,108.36 ; UC1.K60 98.66,108.67 ; UC1.K60 98.66,108.01 ; 96.99,102.9 UC1.AA63 ; UC1.AA63 96.99,102.29 ; UC1.AA63 96.73,102.6 ; UC1.AA63 97.27,102.6 ; 97.76,104.88 UC1.T62 ; UC1.T62 97.17,104.88 ; UC1.T62 97.46,105.19 ; UC1.T62 97.46,104.59 ; UC1.K48 105.07,108.63 ; UC1.K48 105.07,107.99 ; UC1.K48 104.76,108.36 ; UC1.K48 105.37,108.36 ; 104.06,108.83 104.05,108.83 UC1.J50 ; 101.41,108.67 UC1.K55 ; UC1.K55 101.71,108.36 ; UC1.K55 101.41,108.01 101.4,108.01 ; UC1.K55 101.1,108.36 ; UC1.J56 100.04,108.52 ; UC1.J56 100.37,108.83 ; UC1.K53 102.32,108.06 ; UC1.K53 102.02,108.36 ; UC1.K53 102.32,108.7 ; UC1.R63 96.99,105.02 ; UC1.R63 96.99,105.68 ; UC1.R63 96.68,105.34 ; UC1.R63 97.29,105.34 ; 105.91,108.83 105.9,108.83 UC1.J46 ; 105.15,108.83 105.15,108.83 UC1.J46 ; UC1.J50 103.69,108.52 ; UC1.J50 103.35,108.83 ; 97.27,103.51 UC1.W63 ; UC1.W63 96.99,103.21 ; UC1.W63 96.68,103.51 ; 99.88,108.36 UC1.K58 ; UC1.K58 99.27,108.36 ; UC1.K58 99.58,108.67 ; UC1.K58 99.58,107.99 ; 97.77,103.05 UC1.Y62 ; UC1.Y62 97.46,102.72 ; UC1.Y62 97.18,103.05 ; 96.99,107.46 UC1.L63 ; UC1.L63 96.99,106.86 ; UC1.L63 96.68,107.17 ; UC1.L63 97.31,107.17 ; 98.21,108.52 UC1.J60 98.55,108.83 ; UC1.J46 105.52,108.52 ; 97.84,107.62 UC1.L62 97.46,107.95 97.48,107.97
  BOTTOM w0.203: v2(97.35,113.92) UC1.A62 ; v2(102.34,113.9) 102.28,113.85 102.28,113.02 UC1.A53 ; v2(94.87,113.98) UC1.A66 ; v2(104.93,113.47) 104.84,113.38 104.84,113.04 UC1.A48 ; v2(99.83,113.93) UC1.A58
  vias: v2(70.76,97.48) v2(70.76,96.85) v2(70.76,96.21) v2(70.76,95.58) v2(71.4,97.48) v2(71.4,96.85) v2(71.4,96.21) v2(71.4,95.58) v2(75.21,96.72) v2(75.21,96.09) v2(75.21,95.45) v2(75.21,94.82) v2(75.84,96.72) v2(75.84,96.09) v2(75.84,95.45) v2(75.84,94.82) v2(76.35,99.26) v2(76.35,98.63) v2(76.35,97.99) v2(76.35,97.36) v2(76.48,96.72) v2(76.48,96.09) v2(76.48,95.45) v2(76.48,94.82) v2(76.99,99.9) v2(76.99,99.26) v2(76.99,98.63) v2(76.99,97.99) v2(76.99,97.36) v2(77.11,96.72) v2(77.11,96.09) v2(77.62,99.9) v2(77.62,99.26) v2(77.62,98.63) v2(77.62,97.99) v2(77.62,97.36) v2(81.75,102.88) v2(81.75,100.09) v2(83.02,102.88) v2(83.02,100.09) v2(84.29,102.88) v2(84.29,100.09) v2(85.5,102.88) v2(85.5,100.09) v2(86.7,102.88) v2(86.7,100.09) v2(87.91,102.88) v2(87.91,100.09) v2(89.11,102.88) v2(89.11,100.09) v2(90.32,102.88) v2(90.32,100.09) v2(92.11,105.8) v2(92.11,103.97) v2(92.11,102.14) v2(92.76,106.65) v2(92.76,104.88) v2(92.76,103.05) v2(93.41,105.8) v2(93.41,102.14) v2(94.06,106.65) v2(94.06,104.88) v2(94.06,103.97) v2(94.06,103.05) v2(94.71,105.8) v2(94.71,102.14) v2(95.36,106.65) v2(95.36,104.88) v2(95.36,103.05) v2(96.01,103.97) v2(96.64,106.65) v2(96.61,105.78) v2(96.64,102.15) v2(96.66,101.26) v2(97.72,105.34) v2(97.72,103.51) v2(97.81,106.24) v2(97.86,102.53) v2(98.14,101.99) v2(98.22,107.96) v2(98.24,103.97) v2(98.24,103.04) v2(98.27,104.85) v2(98.77,100.91) v2(99.13,107.96) v2(100.05,107.96) v2(100.04,100.91) v2(100.07,103.57) v2(100.22,106.09) v2(100.96,107.96) v2(101.34,103.57) v2(101.31,100.91) v2(101.39,106.06) v2(101.88,107.96) v2(102.51,103.57) v2(102.56,106.06) v2(102.58,100.91) v2(103.72,106.06) v2(103.67,103.6) v2(103.85,100.91) v2(104.62,107.96) v2(104.94,106.06) v2(104.89,103.57) v2(105.12,100.91) v2(105.48,107.96) v3(84.86,102.12)
