# Allegro board LAE121PR10-1108.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 41.1
  TOP w0.102: v2(289.84,41.97) 289.84,42.28 v3(289.58,42.53)
  TOP w0.203: v2(254.72,56.72) 254.93,56.72 255.13,56.92 UA1.25 ; v2(261.33,57.73) 261.33,58.01 260.8,58.54 UA1.38
  TOP w0.381: CA41.2 252.7,62.88 v2(253.34,62.88) ; CA57.2 v2(261.96,57.58)
  TOP w0.508: v2(251.74,59.89) CA25.2 250.16,59.89 RA37.1 ; CA2.2 v2(285.14,35.7) ; v2(282.74,32.33) 282.45,32.05 RA39.1 ; CA3.2 v2(285.14,36.9) ; RA38.1 v2(284.4,46.79)
  GND1 w0.203: JHP1.7 291.23,41.1 ; JHP1.7 289.07,41.77 ; JHP1.7 291.23,41.77 ; JHP1.7 290.15,41.77 ; JHP1.7 289.07,41.1 ; 287.5,30.92 JHP1.5 ; JHP1.5 288.58,30.92 ; JHP1.5 286.42,30.92 ; JHP1.5 286.42,31.6 ; JHP1.5 288.58,31.6
  VCC w0.203: 286.42,30.92 JHP1.5 ; JHP1.5 287.5,30.92 ; JHP1.5 288.58,30.92 ; 289.07,41.77 JHP1.7 ; JHP1.7 290.15,41.77 ; JHP1.7 291.23,41.77
  GND2 w0.203: 289.07,41.77 JHP1.7 ; JHP1.7 291.23,41.1 ; JHP1.7 289.07,41.1 ; JHP1.7 291.23,41.77 ; JHP1.7 290.15,41.77 ; JHP1.5 288.58,31.6 ; JHP1.5 288.58,30.92 ; JHP1.5 286.42,30.92 ; JHP1.5 286.42,31.6 ; JHP1.5 287.5,30.92
  BOTTOM w0.508: CA4.2 v2(285.9,46.76) ; v2(286.66,42.87) 286.66,43.58 CA1.1
  vias: v2(252.44,54.37) v2(252.44,53.73) v2(255.36,53.35) v2(265.39,57.54) v2(265.39,56.91) v2(283.77,32.29) v2(284.91,30.97) v2(290.45,41.97) v3(252.58,52.44) v3(254.48,52.13)
VBAT1_ISL88738: length 4.3
  TOP w0.203: v2(58.38,53.67) 57.52,54.53 PU901.31
  TOP w0.254: PR940.2 v2(58.38,53.67)
  BOTTOM w0.112: v1(59.43,53.47) 59.23,53.67 v2(58.38,53.67)
  BOTTOM w0.203: PC950.2 58.19,54.23 58.19,53.86 v2(58.38,53.67)
VBUS1_ECOK: length 407.2
  TOP w0.112: v2(264.12,95.2) v1(264.91,95.2) 265.17,95.46 265.17,95.84 265.73,96.4 267.69,96.4 268.31,95.78 268.31,95.32 268.25,95.26 UE2.13
  TOP w0.254: v2(42.7,109.1) 42.7,107.85 PR1222.1 PR1220.1
  IN2 w0.124: v2(260.45,76.14) 258.77,76.14 257.86,77.05 253.34,77.05 252.47,76.19 249.76,76.19 249.34,75.77 245.94,75.77 244.51,77.2 240.69,77.2 240.1,77.79 236.82,77.79 235.86,76.83 235.86,76.28 235.18,75.61 235.18,74.66 234.73,74.2 233.8,74.2 232.49,72.89 230.84,72.89 227.66,69.71 226.08,69.71 225.78,69.4 222.07,69.4 221.11,68.44 207.76,68.44 206.48,69.73 187.07,69.73 185.38,71.42 181.85,71.42 172.26,81.01 172.26,83.58 169.9,85.95 169.9,88.53 167.64,90.79 167.64,105.76 162.89,110.5 162.89,119.27 162.27,119.9 162.27,120.69 159.09,123.87 159.09,128.66 156.61,131.14 155.22,131.14 154.71,130.63 148.49,130.63 144.68,134.44 136.17,134.44 134.17,132.45 117.78,132.45 117.36,132.03 109.37,132.03 109.12,132.28 104.29,132.28 103.4,131.39 83.16,131.39 79.56,127.79 75.42,127.79 75.11,128.1 67.77,128.1 67.44,127.77 62.72,127.77 61.75,126.8 47.61,126.8 46.17,125.36 41.52,125.36 39.63,123.47 37.15,123.47 31.56,117.88 31.56,112.88 32.92,111.52 35.65,111.52 37.37,109.79 41.2,109.79 41.88,109.1 v2(42.7,109.1) 42.7,108.9 41.55,107.76 41.55,103.77 42.67,102.65 42.67,98.87 41.55,97.74 41.55,86.05 39.2,83.7 39.2,81.8 39.9,81.1 39.9,77.99 38.19,76.27 38.19,64.73 41.54,61.38 41.54,53.11 42.12,52.53 43.33,52.53 43.71,52.91 46.7,52.91 v2(47.32,53.53)
  BOTTOM w0.112: v2(47.32,53.53) 47.38,53.47 PR1257.1 ; v2(264.12,95.2) 263.16,95.2 260.81,92.86 260.07,92.86 259.5,92.28 259.5,87.31 260.48,86.32 260.48,85.25 260.6,85.13 260.6,79.02 260.34,78.76 260.34,76.25 v2(260.45,76.14)
VBUS2_ECOK: length 397.5
  TOP w0.112: v2(265.48,94.3) 266.05,93.72 UE2.16 ; PR1242.1 v1(47.97,53.02) v2(47.97,53.54)
  IN2 w0.124: v2(47.97,53.54) 47.01,54.49 44.92,54.49 43.2,52.78 42.32,52.78 41.77,53.33 41.77,61.55 38.44,64.88 38.44,76.17 40.16,77.89 40.16,81.23 39.46,81.93 39.46,83.58 41.8,85.92 41.8,97.67 42.9,98.77 42.9,102.75 41.98,103.67 41.98,107.78 43.1,108.9 43.1,109.31 42.9,109.51 41.91,109.51 41.32,110.09 40,110.09 39.78,110.32 39.78,110.88 v2(40.16,111.26) 39.71,111.71 39.71,112.47 40.03,112.79 41.91,112.79 43.36,114.24 43.36,117.01 38.78,121.59 38.78,122.74 39.22,123.18 39.65,123.18 41.58,125.11 46.23,125.11 47.7,126.58 61.85,126.58 62.79,127.52 67.59,127.52 67.92,127.85 74.98,127.85 75.27,127.56 79.65,127.56 83.22,131.13 103.52,131.13 104.35,131.96 108.99,131.96 109.18,131.77 117.49,131.77 117.93,132.22 134.33,132.22 136.3,134.19 143.6,134.19 144.45,133.34 145.4,133.34 148.36,130.38 154.84,130.38 155.35,130.88 156.55,130.88 158.87,128.57 158.87,123.77 162.04,120.59 162.04,119.8 162.67,119.18 162.67,110.41 167.36,105.72 167.36,90.75 169.67,88.44 169.67,85.85 172.04,83.49 172.04,80.88 181.72,71.2 185.28,71.2 187,69.48 206.37,69.48 207.64,68.22 221.24,68.22 222.15,69.12 225.83,69.12 226.19,69.48 227.76,69.48 230.91,72.64 232.59,72.64 233.9,73.95 234.83,73.95 235.43,74.55 235.43,75.51 236.11,76.18 236.11,76.76 236.92,77.57 239.99,77.57 240.58,76.98 244.38,76.98 245.84,75.52 249.36,75.52 249.76,75.12 250.29,75.12 251.1,75.93 252.6,75.93 253.47,76.8 257.79,76.8 258.95,75.64 260.79,75.64 261.1,75.95 v2(261.1,76.82)
  BOTTOM w0.112: v2(261.1,76.82) 261.1,78.81 263.18,80.89 263.18,84.66 263.5,84.97 264.01,84.97 266.19,87.16 266.19,93.56 265.48,94.27 v2(265.48,94.3) ; PR24.1 40.33,111.44 v2(40.16,111.26)
  BOTTOM w0.254: PR20.2 41.16,111.33 PR24.1
VBUS3_ECOK: length 2
  TOP w0.107: UE1.F13 250.68,95.22 T264.1
VCC_GT_SENSE: length 62.7
  TOP w0.112: PC620.1 51.14,88.34 v1(51.52,87.96) ; RC161.1 87.78,107.95 87.78,108.66 v2(87.46,108.98)
  TOP w0.203: PC620.1 50.28,88.9 PC617.1 50.25,89.33 50.27,89.34 PR622.1 50.11,89.95 v2(50.11,90.51)
  IN1 w0.119: v2(50.11,90.51) 50.11,90.55 50.49,90.93 50.52,90.93 50.76,91.16 51.64,91.16 52.2,90.61 53.65,90.61 54.04,91.01 54.63,91.01 55.01,90.63 56.75,90.63 57.38,90 68.63,90 72.16,93.53 72.16,99.71 78.37,105.91 78.37,106.87 80.21,108.72 87.2,108.72 v2(87.46,108.98)
  BOTTOM w0.076: 90.4,108.28 90.41,108.28 90.43,108.3 90.53,108.3 90.54,108.28 91.35,108.28 91.46,108.17 91.98,108.17 92.15,108.29 92.29,108.43 UC1.J70
  BOTTOM w0.112: 90.4,108.28 89.62,108.28 88.51,109.4 87.88,109.4 v2(87.46,108.98)
  BOTTOM w0.203: v2(50.11,90.51) 50.11,90.21 PC618.2
VCCIO_SENSE: length 98.8
  TOP w0.112: v2(118.32,96.71) 117.83,96.71 RC165.1 ; v2(131.82,130.62) 131.99,130.45 131.99,128.87 135.87,124.99 144.78,124.99 146.09,123.69 149.62,123.69 151.37,121.94 151.37,105.65 153.11,103.91 153.11,99.71 152,98.61 148.46,98.61 v2(148.26,98.8)
  IN3 w0.135: v2(148.26,98.8) 148.11,98.65 146.53,98.65 146.19,99 145.03,99 144.87,98.84 142.93,98.84 142.8,98.7 142.14,98.7 141.26,97.83 137.88,97.83 137,96.94 135.56,96.94 134.64,97.86 132.76,97.86 131.62,98.99 130.4,98.99 130.27,99.13 125.13,99.13 124.26,99.99 119.44,99.99 118.48,99.04 118.48,97.62 118.73,97.37 118.73,96.88 118.55,96.71 v2(118.32,96.71)
  BOTTOM w0.076: UC1.AM23 v2(118.32,96.71)
  BOTTOM w0.112: PR422.2 138.95,134.12 135.57,134.12 133.46,132.01 132.45,132.01 131.99,131.55 131.99,130.8 v2(131.82,130.62)
VCCSA_B+: length 0.9
  BOTTOM w0.112: 66.65,112.91 v1(66.65,112.05)
  vias: v2(64.16,113.85) v2(64.77,113.85)
VCCSENSE: length 91.2
  TOP w0.112: RC140.1 110.39,120.22 110.39,118.44 112.03,116.8 112.03,114.74 v2(111.85,114.56)
  TOP w0.203: v2(53.9,95.18) 54.15,95.44 PC653.1 ; PC653.1 55.37,95.44 PC651.2 ; PC653.1 PR648.1 54.52,94.56 PC639.1
  IN1 w0.119: v2(53.9,95.18) 54.14,95.43 55.74,95.43 59.76,99.45 59.76,101.52 61.13,102.89 70.81,102.89 71.14,103.22 74.62,103.22 77.72,106.31 77.72,107.12 80.47,109.87 91.07,109.87 93.55,112.36 95.63,112.36 96.67,111.31 96.67,110.12 97.88,108.91 107.58,108.91 108.02,109.36 108.02,113.65 109.39,115.02 111.39,115.02 v2(111.85,114.56)
  BOTTOM w0.076: UC1.E32 113.71,111.09 113.71,111.52 113.78,111.6 113.78,111.84 113.68,111.94 113.68,112.09 113.78,112.19 113.78,112.46
  BOTTOM w0.102: v2(111.85,114.56) 112.06,114.77 112.06,115.05 112.3,115.28 112.89,115.28 113.71,114.47 113.71,112.54 113.78,112.46
VCCST_PWRGD: length 334.1
  TOP w0.107: v2(261.49,101.36) 261.39,101.46 258.82,101.46
  TOP w0.112: UE4.4 271.18,98.1 271.74,97.55 v1(271.74,95.3) 271.2,94.76 270.38,94.76 270.13,95.01 270.13,95.46 269.05,96.54 v2(268.43,96.54) ; 258.82,101.46 258.42,101.05 RE308.1
  IN1 w0.119: v2(74.38,65) 74.43,65.05 138.94,65.05 140.69,63.3 140.69,61.94 143.42,59.21 146.05,59.21 146.6,59.75 148.5,59.75 148.83,59.42 156.87,59.42 158.44,57.85 162.28,57.85 164.44,55.69 171.96,55.69 172.7,54.95 178.16,54.95 180.11,52.99 184.63,52.99 187.73,49.9 238.54,49.9 242.04,53.39 242.04,58.16 248.41,64.53 250.41,64.53 252.13,66.24 259.83,66.24 260.3,65.77 261.2,65.77 262.91,67.48 262.91,70.15 v2(262.74,70.32)
  IN3 w0.135: v2(74.38,65) 74.52,65.14 74.52,71.96 75.75,73.19 75.75,85.9 v2(75.78,85.93) ; v2(79.17,111.16) 78.64,111.69 78.64,114.97 80.77,117.1 87.63,117.1 88.86,118.34 88.86,118.62 91.64,121.4 v2(91.69,121.4)
  BOTTOM w0.112: v2(261.49,101.36) 261.95,100.9 263.93,100.9 264.19,101.16 264.79,101.16 265.04,100.9 265.04,98.67 267.13,96.58 268.4,96.58 v2(268.43,96.54) 268.55,96.54 269.23,95.87 269.23,94.45 269.84,93.84 269.84,91.03 269.14,90.33 269.14,84.75 268.88,84.49 268.88,79.36 265.66,76.13 265.66,75.65 262.57,72.56 262.57,70.49 v2(262.74,70.32) ; v2(79.17,111.16) 79.08,111.07 79.08,93.97 77.41,92.3 77.41,88.25 75.78,86.62 v2(75.78,85.93) ; RC78.1 CC301.1 RC123.1 RC71.1 91.45,120.65 91.69,120.88 v2(91.69,121.4)
VCCST_PWRGD_CPU: length 9.5
  BOTTOM w0.076: 93.56,116.9 93.93,116.9 94.97,115.86 94.97,115 95.85,114.12 95.85,112.96 UC1.B65
  BOTTOM w0.112: 93.56,116.9 91.95,116.9 v1(90.89,117.96) RC78.2
VCCST_PWRGD_EC: length 14
  TOP w0.107: UE1.K10 v2(254.28,91.46)
  TOP w0.112: RE308.2 256.77,100.95 v1(256.65,100.95) 256.42,100.95 255.61,100.14 254.28,100.14 v2(254.23,100.09)
  IN1 w0.119: v2(254.23,100.09) 254.47,99.85 254.47,98.83 253.85,98.21 253.85,96.12 253.57,95.85 253.57,94.12 253.89,93.8 253.89,91.86 v2(254.28,91.46)
VCCSTG_EN: length 111
  TOP w0.112: UZ19.4 121.38,128.49 v2(120.97,128.9) ; v2(148.77,64.48) 148.71,64.42 147.67,64.42 147.27,64.82 144.13,64.82 142.65,66.3 RZ120.1
  IN1 w0.119: v2(150.91,65.87) 146.84,69.94 146.84,76.29 147.23,76.67 147.23,79.2 146.84,79.58 146.84,85.98 146.64,86.18 146.64,87.12 145.68,88.08 145.68,93.05 143.6,95.13 140.22,95.13 v2(138.68,96.67)
  IN2 w0.124: v2(120.97,128.9) 122.14,128.9 123.05,127.99 124.54,127.99 124.87,128.33 128.6,128.33 129.14,127.79 138.84,127.79 139.47,128.42 140.08,128.42 140.1,128.4 140.1,125.14 139.13,124.17 139.13,122.95 140,122.08 140,118.9 137.9,116.8 137.9,112.89 138.84,111.95 138.84,111.11 142.27,107.68 142.27,103.36 139.19,100.28 139.19,98.15 138.68,97.64 v2(138.68,96.67)
  IN3 w0.135: v2(150.91,65.87) 150.16,65.87 v2(148.77,64.48)
  BOTTOM w0.112: RZ320.2 122.88,129.04 UZ35.4 121.61,129.47 v1(121.41,129.27) 121.04,128.9 v2(120.97,128.9)
VDD_ISL88738: length 21.3
  TOP w0.112: v2(53.47,58.29) 53.47,58.45 v1(53.03,58.89) ; PR919.1 50.49,58.43 v2(49.94,58.43)
  TOP w0.203: v2(53.47,58.29) 53.77,58.29 54.03,58.04 PU901.18
  TOP w0.254: v2(62.48,59.26) PR915.2
  IN1 w0.254: v2(49.94,58.43) 51.27,58.43 51.78,58.94 52.92,58.94 53.47,58.39 v2(53.47,58.29)
  IN2 w0.254: v2(62.48,59.26) 59.96,61.78 58.1,61.78 57.39,61.07 55.28,61.07 53.47,59.26 v2(53.47,58.29)
  BOTTOM w0.203: PC933.1 53.12,57.35 PR918.2 52.98,57.54 53.47,58.03 v2(53.47,58.29)
VDDP_ISL88738: length 3.6
  TOP w0.203: PU901.8 58.89,58.44 59.33,58.88 v2(59.33,59.26)
  TOP w0.254: PR915.1 v1(59.92,59.26) v2(59.33,59.26)
  BOTTOM w0.254: v2(59.33,59.26) 58.9,58.82 PC932.2
VIN_1V_PRIM: length 1
  TOP w0.112: PC413.1 v1(160.62,127.71)
  vias: v2(160.3,129.4) v2(160.93,129.4)
VIN_1VS_VCCIO: length 1.1
  TOP w0.112: PC408.1 146.06,130.17 146.28,129.96 v1(146.73,129.96)
  vias: v2(144.42,130.86) v2(145.06,130.86)
VSS_GT_SENSE: length 61.3
  TOP w0.112: RC163.1 88.1,108.52 v2(88.1,108.98)
  TOP w0.203: PC620.2 50.7,90.26 v2(50.7,90.51) 50.7,90.61 50.33,90.97 PU602.6
  IN1 w0.119: v2(50.7,90.51) 50.7,90.75 50.86,90.92 51.54,90.92 52.09,90.37 53.75,90.37 54.15,90.76 54.53,90.76 54.91,90.38 56.65,90.38 57.28,89.76 68.73,89.76 72.41,93.43 72.41,99.6 78.61,105.81 78.61,106.77 80.31,108.47 87.59,108.47 v2(88.1,108.98)
  BOTTOM w0.076: 90.44,108.08 91.27,108.08 91.34,108 92.07,108 92.33,108.17 92.62,108.17 92.88,108.43 UC1.J69
  BOTTOM w0.112: v2(88.1,108.98) 88.28,109.16 88.41,109.16 89.52,108.04 90.4,108.04 90.44,108.08
  BOTTOM w0.203: PC619.2 51,89.39 51,90.21 v2(50.7,90.51)
VSSIO_SENSE: length 97.8
  TOP w0.112: v2(119.31,96.71) 119.28,96.71 RC167.1 ; v2(132.4,130.62) 132.23,130.45 132.23,128.97 135.97,125.23 144.88,125.23 146.19,123.93 149.72,123.93 151.61,122.03 151.61,105.75 153.35,104.01 153.35,99.61 152.1,98.37 148.41,98.37 v2(148.26,98.22)
  IN3 w0.135: v2(148.26,98.22) 148.09,98.39 146.42,98.39 146.08,98.73 145.14,98.73 144.98,98.58 143.04,98.58 142.91,98.44 142.25,98.44 141.37,97.56 137.99,97.56 137.1,96.68 135.45,96.68 134.53,97.6 132.65,97.6 131.51,98.73 130.29,98.73 130.16,98.87 125.02,98.87 124.15,99.73 119.55,99.73 118.74,98.93 118.74,97.72 118.99,97.48 118.99,96.85 119.12,96.71 v2(119.31,96.71)
  BOTTOM w0.076: UC1.AM22 v2(119.31,96.71)
  BOTTOM w0.112: v2(132.4,130.62) 132.23,130.8 132.23,131.46 132.55,131.77 133.56,131.77 135.67,133.88 138.66,133.88 138.77,133.77 138.77,133.54 PR412.2
VSSSENSE: length 91
  TOP w0.112: RC141.1 110.63,120.22 110.63,118.53 112.27,116.9 112.27,114.78 v2(112.48,114.56)
  TOP w0.203: PU602.18 53.22,95.17 53.9,95.85 v2(53.9,95.92) 54.33,96.35 PC653.2 55.37,96.35 PC654.2
  IN1 w0.119: v2(112.48,114.56) 111.79,115.26 109.29,115.26 107.78,113.75 107.78,109.46 107.47,109.15 97.98,109.15 96.92,110.22 96.92,111.42 95.73,112.6 93.44,112.6 90.96,110.12 80.37,110.12 77.47,107.22 77.47,106.42 74.52,103.47 71.04,103.47 70.71,103.13 61.03,103.13 59.52,101.63 59.52,99.55 55.64,95.68 54.14,95.68 v2(53.9,95.92)
  BOTTOM w0.076: UC1.E33 113.29,111.39 113.15,111.54 113.15,111.79 113.23,111.87 113.23,112.16 113.16,112.22 113.16,112.53
  BOTTOM w0.102: v2(112.48,114.56) 112.29,114.76 112.29,114.95 112.39,115.06 112.8,115.06 113.48,114.38 113.48,112.84 113.16,112.53
32KHZ_OUT: length 5.2
  TOP w0.107: UE1.F3 v2(250.28,85.06)
  TOP w0.112: v2(249.5,81.6) 249.5,81.42 CE54.1
  IN2 w0.124: v2(250.28,85.06) 250.28,82.38 v2(249.5,81.6)
+AC_IN: length 63.6
  TOP w0.254: PQ1213.3 49.03,103.89 49.27,103.64 49.27,102.86 49.48,102.65 51.36,102.65 PR1251.1
  IN3 w0.254: v2(45.9,103.8) 45.9,101.71 46.51,101.1 46.51,99.83 46.06,99.39 46.06,98.75 45.05,97.74 45.05,96.59 45.36,96.28 45.36,92.4 45.49,92.28 45.49,89.65 43.65,87.8 43.65,83.45 39.8,79.6 39.8,77.95 38.19,76.34 38.19,63.57 37.43,62.81 37.43,59.95 v2(36.98,59.51)
  BOTTOM w0.102: PR1255.1 32.87,56.13 v1(33.17,55.83)
  BOTTOM w0.254: PR1255.1 32.87,59.02 33.17,59.32 36.79,59.32 v2(36.98,59.51)
  BOTTOM w0.508: PQ1215.3 45.24,102.68 45.9,103.34 v2(45.9,103.8)
  vias: v2(32.41,117.23) v2(32.41,116.62) v2(32.41,116.03) v2(33.04,117.23) v2(33.04,116.62) v2(33.04,116.03) v2(40.22,114.69) v2(40.22,114.08) v2(40.22,113.49) v2(40.85,114.69) v2(40.85,114.08) v2(40.85,113.49) v2(41.49,114.69) v2(41.49,114.08) v2(41.49,113.49) v2(45.59,104.89) v2(45.59,104.3) v2(46.2,104.89) v2(46.2,104.3) v2(46.51,105.42) v2(46.79,104.89) v2(46.79,104.3) v2(47.14,105.42) v2(47.37,104.89) v2(47.37,104.3)
+BL_PWR_SRC: length 14
  TOP w1.524: 56.92,133.11 v3(49.3,133.11) 48.41,132.22 v3(48.41,131.14) v3(48.41,129.3) 46.82,127.71
  vias: v2(59.09,131.62) v2(59.66,131.62) v2(60.23,131.62)
+CHARGER_SRC: length 0.8
  BOTTOM w0.102: 45.62,83.77 v3(44.86,83.77)
  vias: v2(46.53,80.53) v2(47.01,79.07) v2(47.65,79.07) v2(48.47,79.07) v2(48.47,76.27) v2(48.47,75.64) v2(48.47,75) v2(48.47,74.37) v2(48.47,73.73) v2(49.11,79.07) v2(49.11,76.27) v2(49.11,75.64) v2(49.11,75) v2(49.11,74.37) v2(49.11,73.73)
+COINCELL: length 3.8
  TOP w0.127: v2(283.95,8.03) v1(283.95,7.43)
  TOP w0.508: v2(283.95,8.03) 283.95,8.03 PC2.2 283.93,8.98 PR2.1
  BOTTOM w0.508: JRTC1.1 v2(283.95,8.03)
+DC_IN: length 96.2
  TOP w0.508: PR1201.1 42.5,53.35 v2(42.71,53.56)
  IN2 w0.508: v2(45.13,119.38) 45.86,118.65 45.86,114.62 44.3,113.06 44.3,108.77 43.16,107.63 43.16,103.49 43.56,103.08 43.56,96.61 42.49,95.54 42.49,88.76 42.85,88.4 42.85,79.58 39.17,75.89 39.17,67.04 42.57,63.64 42.57,56.65 43.2,56.02 43.2,53.93 42.83,53.56 v2(42.71,53.56)
  BOTTOM w0.508: PU2.2 65.81,120.15 PC11.1 63.08,120.15 62.62,120.61 62.62,121.9 60.62,123.9 v3(53.62,123.9) 49.14,123.9 47.99,122.76 47.14,122.76 46.62,122.24 PR12.1
+DC_IN_SS: length 76.8
  TOP w0.127: v2(46.51,61.67) v3(47.31,61.67)
  IN2 w0.508: v2(46.51,61.67) 47.34,62.49 56.59,62.49 58.72,64.63 58.72,69.89 57.56,71.05 57.56,77.61 55.76,79.4 55.76,83.71 57.96,85.91 57.96,94.37 58.95,95.36 58.95,98.28 58.27,98.97 58.27,101.75 59.74,103.22 59.74,106.73 58.93,107.54 58.93,110.46 58.09,111.3 58.09,115.15 56.23,117 v2(55.85,117)
  BOTTOM w0.508: v2(55.85,117) 52.99,117 PD5.3 ; PD904.2 v2(46.51,61.67)
+DCIN_JACK: length 6.6
  BOTTOM w0.254: v3(38.25,125.93) 38.7,125.93 v3(39.78,124.85) 40.73,123.9 v3(40.73,122.5) 40.73,121.29 PL4.1
+DCPRTC: length 9
  TOP w0.381: v2(131.47,86.69) 131.47,85.74 131.81,85.39 CC214.1
  BOTTOM w0.203: v2(131.47,86.69) v1(130.78,87.38) 128.74,89.42 128.37,89.42 127.81,89.98 127.23,89.98 126.85,90.35 UC1.BB10
+DDR_VREF_A_CA: length 6.3
  TOP w0.127: v2(118.98,55) v1(118.98,55.61)
  TOP w0.508: CD25.1 CD26.1 ; CD25.1 117.89,53.29 RD17.1 ; CD25.1 RD16.1 ; CD26.1 RD15.2 ; CD26.1 118.76,54.78 v2(118.98,55)
  BOTTOM w0.305: v2(118.98,55) 118.98,53.7 JDIMM1.164
+DDR_VREF_A_DQ: length 1.1
  TOP w0.254: T132.1 v2(93.09,91.98)
  BOTTOM w0.203: UC1.AY68 93.34,91.73 v2(93.09,91.98)
+DDR_VREF_B_DQ: length 1.4
  TOP w0.254: T226.1 94.21,91.22 v2(93.7,91.22)
  BOTTOM w0.203: UC1.BA67 93.81,91.34 v2(93.7,91.22)
+DDR_VREF_CA: length 104.9
  TOP w0.508: v2(116.99,51.76) CD31.1 RD17.2 ; v2(74.67,83.58) 76.48,83.58 78.51,81.54 78.51,72.85 v3(75.13,69.47) 73.49,67.83 73.49,64.65 74,64.15 v2(74.38,64.15)
  IN1 w0.508: v2(74.38,64.15) 76.54,61.99 76.54,54.56 77.24,53.86 116.36,53.86 116.99,53.22 v2(116.99,51.76)
  BOTTOM w0.203: 91.53,89.25 92.01,89.74 94.4,89.74 94.72,90.05 94.72,90.63 94.55,90.8 94.55,91.51 94.2,91.85 UC1.AY67
  BOTTOM w0.508: 91.53,89.25 90.47,88.2 90.47,86.85 87.2,83.58 v2(74.67,83.58)
+EC_DEBUG_VCC: length 1.4
  TOP w0.127: v2(289.82,126.63) 288.96,127.48 v3(288.76,127.48)
+EDP_VDD:
  vias: v1(67.55,126.95)
+LCDVDD:
  vias: v2(65.43,131.13) v2(65.43,130.55) v2(65.43,129.98) v3(66.57,133.81) v3(68.1,134.63) v3(69.62,133.81)
+LINE1-VREFO-L: length 2.3
  TOP w0.203: UA1.31 257.53,56.55 257.45,56.47 v1(257.45,56.07) RA57.1
+LINE1-VREFO-R: length 2.5
  TOP w0.203: UA1.30 257.13,56.61 257.01,56.5 257.01,55.46 RA58.1
+MIC2-VREFO: length 16.7
  TOP w0.112: v2(256.06,53.35) v1(256.06,52.82)
  TOP w0.203: 256.5,55.95 256.5,56.46 256.73,56.69 UA1.29
  TOP w0.254: v2(256.06,53.35) 255.93,53.48 255.93,55.38 256.5,55.95
  TOP w0.508: v2(250.22,60.63) 250.56,60.97 RA6.1 RA5.1
  IN2 w0.508: v2(256.06,53.35) 256.06,53.99 252.82,57.22 252.82,58.24 251.87,59.19 251.08,59.19 250.22,60.06 v2(250.22,60.63)
+PBATT: length 126.3
  TOP w0.254: v2(58.15,51.47) 58.38,51.7 PR940.1
  TOP w0.508: PL1.2 170.75,59.28 168.35,59.28 167.97,58.91 167.44,58.91 163.32,54.79 v2(163.32,51.93)
  IN1 w0.508: v2(144.14,52.11) 144.16,51.96 144.76,51.47 145.54,51.47 148.68,54.61 159.27,54.61 161.95,51.93 v2(163.32,51.93)
  IN3 w0.508: v2(58.15,51.47) 58.15,51.9 58.92,52.68 62.57,52.68 64.95,55.06 69.18,55.06 71.22,53.02 72.06,53.02 74.8,50.28 138.99,50.28 141.5,52.79 143.46,52.79 v2(144.14,52.11)
  vias: v3(176.6,59.47)
+PECI_VREF: length 7
  TOP w0.254: UE1.J11 v2(253.48,92.26)
  TOP w0.381: RE59.1 CE25.1 254.76,96.44 254.46,96.14 254.46,94.87 v2(253.96,94.37)
  BOTTOM w0.254: v2(253.96,94.37) 253.49,94.37 253.01,93.89 253.01,92.73 v2(253.48,92.26)
+PWR_SRC: length 146.8
  TOP w0.254: RZ85.1 223.53,52.3 223.72,52.11 v2(224.46,52.11)
  IN2 w0.508: v2(47.84,58.42) 48.77,59.35 52.6,59.35 54.99,61.73 57.1,61.73 57.85,62.48 62.88,62.48 63.4,63 63.4,64.97 v2(61.3,67.07)
  IN2 w1.524: 57.17,119.29 56.51,119.95 55.03,119.95 52.65,122.32 47.99,122.32 46.62,120.95 43.74,120.95
  IN3 w1.524: 58,116.47 58,112.22 59.14,111.07 59.14,107.58 60.48,106.25 60.48,99.07 58.57,97.16 58.57,95.13 57.62,94.18 57.62,86.31 56.41,85.1 56.41,83.26 57.36,82.31
  BOTTOM w0.254: v2(61.3,67.07) 61.97,66.39 61.97,64.76 61.76,64.54 PR929.2 ; v2(224.46,52.11) 221.84,49.49 183.72,49.49 ; PR102.2 181.77,59.12 180.77,59.12 180.16,58.51 179.59,58.51 179.03,59.07 178.33,59.07 176.81,57.54 176.81,52.27 179.09,49.99 180.14,49.99 v2(180.32,50.17)
  BOTTOM w0.508: PD901.2 46.96,57.54 v2(47.84,58.42)
  vias: v2(42.13,122.17) v2(42.73,122.17) v2(43.31,122.17) v2(57.62,117.93) v2(58,117.49) v2(58.38,117.93) v2(58.42,81.86) v2(58.4,81.16) v2(58.42,80.49) v2(60.03,76.08) v2(60.03,74.37) v2(60.03,72.78) v2(60.03,70.94) v2(60.67,76.08) v2(60.67,74.37) v2(60.67,72.78) v2(60.67,70.94) v2(60.67,68.65) v2(60.67,67.07) v2(61.3,68.65) v2(73.49,77.48) v2(73.49,76.85) v2(73.49,76.21) v2(74.13,77.48) v2(74.13,76.85) v2(74.13,76.21) v2(74.76,77.48) v2(74.76,76.85) v2(74.76,76.21) v2(164.72,51.81) v2(164.72,51.18) v2(164.72,50.54) v2(165.35,51.81) v2(165.35,51.18) v2(165.35,50.54) v2(165.99,51.81) v2(165.99,51.18) v2(165.99,50.54) v2(166.62,51.81) v2(166.62,51.18) v2(166.62,50.54) v2(167.26,51.81) v2(167.26,51.18) v2(167.26,50.54) v2(167.89,51.81) v2(167.89,51.18) v2(167.89,50.54) v2(168.53,51.81) v2(168.53,51.18) v2(168.53,50.54) v2(180.32,49.58) v2(180.9,50.17) v2(180.9,49.57) v2(181.54,50.17) v2(181.54,49.57) v2(182.17,50.17) v2(182.17,49.57) v3(165.82,53.35)
+PWR_SRC_AC:
  vias: v2(50.95,81.23) v2(50.95,80.59) v2(51.59,81.23) v2(51.59,80.59) v2(52.22,81.23) v2(52.22,80.59) v2(52.86,81.23) v2(52.86,80.59) v2(53.49,81.23) v2(53.49,80.59) v3(53.62,83.83)
+PWR_SRC_R: length 20.6
  TOP w0.254: RZ85.2 224.81,52.84 225.22,52.44 v3(225.88,52.44) 227.91,52.44 228.85,51.5 234.28,51.5 235.74,52.96 235.74,58.1 v2(234.39,59.45)
  BOTTOM w0.305: JUSH1.1 233.97,59.02 v2(234.39,59.45)
+REGCTL_PNP10: length 1.5
  BOTTOM w0.127: LL1.1 v1(249.96,125.07)
  vias: v2(246.53,121.78) v2(246.53,121.2) v2(250.82,124.34) v2(251.23,123.95)
+RREF: length 4.4
  TOP w0.127: RR4.1 v1(270.99,60.82)
  TOP w0.203: 273.68,62.32 273.87,62.5 UR1.9
  TOP w0.305: 273.68,62.32 271.55,62.32 RR4.1
+RSVD_VCC3P3_1: length 4
  TOP w0.203: RL6.1 v1(242.02,121.75) 242.71,122.44 243.87,122.44 244.08,122.64 UL1.1
+RTC_CELL: length 398
  TOP w0.381: RC69.2 126.49,83.95 CC270.1 126.77,84.62 126.77,85.18 126.49,85.46 126.49,88.91 125.27,90.13 v2(124.42,90.13)
  TOP w0.508: RE32.1 RE31.1 v2(245.07,78.64) ; v2(229.45,88.83) 229.91,89.29 229.91,95.57 229.06,96.41 229.06,109.37 235.06,115.36 237.67,115.36 239.55,113.48 242.34,113.48 244.41,111.42 v2(245.74,111.42) ; v2(143.18,80.08) 144.03,80.08 144.63,79.49 144.63,76.06 149.6,71.08 160.95,71.08 163.3,73.43 169.71,73.43 171.32,75.04 177.14,75.04 arc(180.69,73.24) 184.1,71.16 arc(188.1,69.64) 192.33,68.97 209.78,68.97 213.69,72.88 220.34,72.88 arc(223.62,74.32) 225.05,77.59 v2(225.77,78.31) ; PD3.1 PC3.1 v3(285.9,18.58) 285.9,23.38 280.5,28.78 280.5,49.67 278.41,51.76 278.41,54.18 v2(277.72,54.88) ; RE508.2 RE507.2 237.78,84.39 236.82,83.42 235.93,83.42 232.9,80.4 232.9,78.17 v2(233.64,77.43) ; RE324.2 v2(246.21,74.22) ; v2(248.5,59.07) RA54.2 ; RC69.2 RC57.2 126.5,82.38 126.83,82.05 127.21,82.05 128.61,80.66 v2(130.77,80.66) RC56.2
  IN1 w0.508: v2(229.45,88.83) 229.45,83.08 225.77,79.4 v2(225.77,78.31) ; v2(130.77,80.66) 130.77,78.43 131.67,77.53 138.28,77.53 140.82,80.08 v2(143.18,80.08) ; v2(245.07,78.64) 245.07,76.5 246.21,75.36 v2(246.21,74.22) 244.61,74.22 243.64,73.24 243.64,71.92 242.96,71.25 241.06,71.25 239.13,73.18 239.13,76.13 237.82,77.43 v2(233.64,77.43)
  IN2 w0.508: v2(233.64,77.43) 231.6,77.43 230.72,78.31 v2(225.77,78.31) ; v2(277.72,54.88) 274.4,54.88 272.58,56.7 268.95,56.7 264.66,52.42 252.46,52.42 250.5,54.38 250.5,57.19 248.63,59.07 v2(248.5,59.07)
  IN3 w0.508: v2(264.16,110.55) 264.95,110.55 271.74,103.76 271.74,99.9 273.61,98.03 275.33,98.03 276.29,97.07 276.29,85.5 281.65,80.15 281.65,72.21 282.43,71.43 282.43,63.11 281.58,62.27 280.36,62.27 278.61,60.51 278.61,58.48 277.72,57.59 v2(277.72,54.88)
  BOTTOM w0.178: UC1.BB14 124.43,90.15 v2(124.42,90.13)
  BOTTOM w0.254: UC1.AK19 v2(121.07,97.34)
  BOTTOM w0.508: v2(264.16,110.55) 263.9,110.81 252.3,110.81 251.71,110.21 246.25,110.21 245.74,110.72 v2(245.74,111.42)
+RTC_CELL_VBAT: length 5.3
  TOP w0.254: v2(246.18,84.28) 246.3,84.28 UE1.A2 ; v2(244.68,81.81) 244.47,81.61 CE11.1 244.47,80.69 RE32.2
  IN1 w0.254: v2(244.68,81.81) 244.91,82.04 244.91,82.42 246.18,83.69 v2(246.18,84.28)
+SDC_IN: length 51.5
  TOP w0.102: PR944.1 v1(51.5,63.17)
  TOP w0.508: PR10.1 51.85,114.96 51.6,114.7 PQ5.3 49.54,114.7 49.47,114.78 47.8,114.78 46.61,113.59 46.61,112.56 45.24,111.19 45.24,110.37 45.6,110.01 47.08,110.01 PC1203.1 ; PR944.1 51.71,62.14 53.11,60.74 PR943.1 52.73,60.21 v2(52.4,60.21)
  IN3 w0.508: v2(46.13,84.91) 46.13,81.29 44.47,79.64 44.47,74.62 41.68,71.83 41.11,71.83 40.85,71.58 40.85,69.07 46.82,63.11 51.2,63.11 52.4,61.9 v2(52.4,60.21)
  vias: v2(46.63,85.23) v2(47.14,84.91) v2(47.65,85.23) v2(48.16,84.91) v2(48.67,85.23) v2(48.79,111.2) v2(48.79,110.56) v2(49.17,84.91) v2(49.43,111.2) v2(49.43,110.56) v2(49.68,85.23) v2(50.06,111.2) v2(50.06,110.56) v2(50.19,84.91) v2(50.7,111.2) v2(50.7,110.56) v2(50.7,85.23) v2(51.33,111.2) v2(51.33,110.56)
+SDREG2: length 1
  TOP w0.127: 278.81,66.97 v1(278.81,67.96)
+SIM_PWR: length 100.1
  TOP w0.127: v2(275.49,55.76) v3(276.38,54.87)
  IN3 w0.508: v2(272.21,62.81) v2(277.21,62.81)
  BOTTOM w0.305: JNGFF2.28 239,103
  BOTTOM w0.508: v2(277.21,62.81) 277.65,62.38 CZ41.1 CZ37.1 279.28,62.06 280.5,60.84 284,60.84 284.51,61.35 JSIM1.C1 ; RZ335.1 v2(275.49,55.76) 274.88,55.76 270.76,59.88 270.76,61.89 271.45,62.57 271.97,62.57 v2(272.21,62.81) 272.21,64.02 272.06,64.17 272.06,95.09 267.83,99.32 267.27,99.32 266.97,99.63 266.97,102.83 266.01,103.79 253.19,103.79 252.72,103.31 248.71,103.31 248.47,103.08 245.59,103.08 245.1,103.56 239.7,103.56 239.14,103 239,103
+TBTA_LDO_BMC: length 3.4
  TOP w0.203: CT71.1 32.8,85.61 32.43,85.61 32.21,85.38 32.21,84.34 32.02,84.15 UT5.E1
+TBTA_VBUS: length 1.2
  BOTTOM w0.381: CT189.1 9.38,110.62 v2(9.36,110.59) CT100.1
  vias: v2(8.74,108.39) v2(8.74,105.88) v2(9.32,108.39) v2(9.35,105.88) v2(16.66,115.77) v2(16.66,115.14) v2(16.66,114.5) v2(17.3,115.77) v2(17.3,115.14) v2(17.3,114.5) v2(21.3,115.77) v2(21.3,115.14) v2(21.3,114.5) v2(21.93,115.77) v2(21.93,115.14) v2(21.93,114.5) v3(8.98,105.36)
+TBTA_VBUS_1: length 36.4
  TOP w0.508: PQ1206.5 27.99,121.68 27.85,121.81 PR1227.1 ; v2(38.05,52.89) 37.96,52.89 PR1239.1
  IN2 w0.508: 21.68,74.81 21.68,67.84 22.73,66.79 22.73,60.49 30.33,52.89 v2(38.05,52.89)
  vias: v2(16.28,78.24) v2(16.6,78.81) v2(16.92,78.24) v2(17.49,103.07) v2(17.49,102.44) v2(17.61,78.12) v2(17.61,77.54) v2(17.61,76.91) v2(26.44,117.3) v2(26.44,116.66) v2(26.44,116.03) v2(26.44,115.39) v2(26.44,114.76) v2(26.44,114.12) v2(28.41,77.61) v2(28.85,77.23) v2(28.98,77.8) v2(29.42,77.23) v2(29.55,77.8) v2(30.12,77.99) v2(34.49,78.88) v3(18.44,75.83)
+USB_EX2_PWR: length 2.2
  TOP w0.127: v2(18.57,55.83) v3(20.75,55.83)
  vias: v2(18.06,67.19) v2(18.06,66.56) v2(18.57,57.73) v2(18.57,57.1) v2(18.57,56.46) v2(18.69,67.19) v2(18.69,66.56)
+UZ12_TPM:
  vias: v1(162.52,115.78)
+VCHGR: length 1.9
  TOP w0.127: v3(178.94,51.04) 178.32,51.66 177.25,51.66
+VHDMI_VCC: length 1.1
  TOP w0.254: v2(15.9,90.18) 15.95,90.18 16.53,90.77 RV22.2
  vias: v2(15.9,89.08) v2(15.9,88.47) v3(15.39,89.67)
+VR_CAP: length 27.2
  TOP w0.127: v1(253.94,80.12) 253.94,80.77 v2(254.02,80.86)
  TOP w0.254: CE31.1 254.86,81.09 253.08,82.87 UE1.J1 ; UE1.C10 v2(247.88,91.46)
  TOP w0.508: v2(254.02,80.86) 254.09,80.8 CE31.1
  IN2 w0.381: v2(244.91,83.09) 249.17,83.09 v2(249.5,82.76)
  IN3 w0.381: v2(247.88,91.46) 246.99,91.46 245.77,90.24 245.77,85.28 244.91,84.41 v2(244.91,83.09) ; v2(254.02,80.86) 254.02,82.38 253.52,82.89 249.63,82.89 v2(249.5,82.76)
+Z4012: length 2.8
  TOP w0.127: v1(285.25,8.89) PD3.2
  TOP w0.508: PR2.2 284.42,10.82 PD3.2
AC1_DISC#: length 51.4
  TOP w0.112: RT72.1 v2(29.93,74.81) ; v2(44.22,57.35) v1(44.22,53.67) 43.46,52.91 43.01,52.91 42.7,52.59 41.01,52.59 40.71,52.3 PR1244.1
  IN1 w0.119: v2(29.93,74.81) 28.73,74.81 26.96,73.05 26.96,67.21 25.11,65.35 23.58,65.35 22.95,64.72 22.95,60.4 26,57.35 v2(44.22,57.35)
  BOTTOM w0.254: PR939.1 v2(44.22,57.35)
AC1_DISC#_R: length 2.6
  TOP w0.076: UT5.G11 31.02,77.79 30.54,77.31
  TOP w0.112: 30.54,77.31 29.93,76.71 RT72.2
AC_DIS: length 308.8
  TOP w0.107: RE83.1 v2(251.8,97.92) 252.25,97.47 252.25,97.27 252.4,97.12 252.6,97.12 252.82,96.9 252.82,95.25 252.7,95.13 252.7,93.08 UE1.H12
  IN2 w0.124: v2(49.1,56.58) 49.68,56.58 50.66,55.6 52.38,55.6 53.16,54.82 58.53,54.82 59.41,53.95 60.29,53.95 61.91,55.57 69.27,55.57 70.25,54.59 71.3,54.59 74.8,51.08 138.65,51.08 142.24,53.87 146.35,53.87 147.99,55.52 158.65,55.52 160.87,53.3 169.92,53.3 173.28,49.95 178.6,49.95 179.83,51.18 182.78,51.18 184.07,49.88 209.31,49.88 210.82,51.39 213.11,51.39 213.71,50.79 237.87,50.79 240.42,53.33 240.42,54.12 242.56,56.26 244.28,56.26 246.15,58.13 246.15,59.98 249.86,63.69 252.22,63.69 252.68,64.15 257.38,64.15 257.83,63.69 258.67,63.69 259.74,64.76 260.89,64.76 263.44,67.31 269.15,67.31 271.27,69.43 271.27,76.95 267.99,80.24 267.99,83.61 266.94,84.66 266.94,87.05 270.81,90.92 v2(271.19,90.92)
  IN3 w0.135: v2(251.8,97.92) 253.2,97.92 255.09,99.81 255.09,101.72 256.22,102.86 263.22,102.86 264.16,101.92 266.83,101.92 268.38,100.37 268.38,98.94 270.46,96.86 270.46,91.65 v2(271.19,90.92)
  BOTTOM w0.112: v1(49.3,55.98) 49.1,56.18 v2(49.1,56.58)
  BOTTOM w0.203: PQ909.2 50.56,56.69 50.81,56.95 PR927.1 50.24,57.29 49.53,56.58 v2(49.1,56.58)
AC_DISC#: length 390.6
  TOP w0.102: PR1231.1 v1(51.19,51.18)
  TOP w0.112: PR1231.1 v2(50.06,50.48) ; PC1217.1 248.94,96.95 249.27,96.62 v2(249.27,95.84) 249.27,95.47 249.88,94.85 UE1.E13 ; PR25.2 53.41,115.68 52.23,116.86 49.06,116.86 45.81,113.61 45.81,112.57 43.18,109.94 v2(42.7,109.94)
  IN2 w0.124: v2(265.65,66.69) 265.17,66.21 262.74,66.21 261.06,64.53 259.87,64.53 258.8,63.46 257.73,63.46 257.3,63.89 252.78,63.89 252.34,63.45 249.95,63.45 246.43,59.93 246.43,58.06 244.39,56.01 242.67,56.01 240.67,54.02 240.67,53.23 238,50.56 213.62,50.56 213.02,51.16 210.91,51.16 209.4,49.65 183.98,49.65 182.68,50.95 179.97,50.95 178.71,49.69 173.18,49.69 169.79,53.08 160.77,53.08 158.56,55.29 148.12,55.29 146.45,53.62 142.29,53.62 138.72,50.86 74.71,50.86 71.2,54.36 70.15,54.36 69.17,55.35 62.14,55.35 61.43,54.63 61.43,52.25 59.16,49.97 50.57,49.97 v2(50.06,50.48) 50.06,51.51 48.73,52.84 48.73,53.54 47.52,54.75 44.79,54.75 43.08,53.03 42.44,53.03 42.02,53.45 42.02,61.64 38.7,64.97 38.7,76.08 40.41,77.8 40.41,81.35 39.71,82.05 39.71,83.45 42.04,85.77 42.04,97.55 43.13,98.64 43.13,102.88 42.24,103.77 42.24,107.68 43.36,108.8 43.36,109.43 42.85,109.94 v2(42.7,109.94) ; v2(249.27,95.84) 250.97,95.84 251.77,96.65 254.68,96.65 256.95,98.92 257.53,98.92 257.7,99.09 258.85,99.09 259.15,98.79 259.15,94.74 260.66,93.23 261.58,93.23 262.85,91.96 262.85,89.22 264.43,87.64 264.43,86.55 264.77,86.21 264.77,83.54 265.24,83.07 265.63,83.07 265.94,82.75 v2(265.94,82.09)
  BOTTOM w0.112: v2(42.7,109.94) 42.7,109.79 42.27,109.36 41.61,109.36 PR1223.2 ; PQ1211.6 47.89,51.78 49.19,50.48 PQ1211.3 v2(50.06,50.48) 50.19,50.61 50.19,51.21 50.76,51.78 PQ1210.6 51.07,52.08 PR1245.1 ; v2(265.94,82.09) 265.94,81.31 264.44,79.81 264.44,75.62 261.73,72.91 261.73,71.03 261.15,70.45 261.15,69.04 262.36,67.83 264.51,67.83 v2(265.65,66.69)
AC_PRESENT: length 189.1
  TOP w0.107: UE1.K8 v2(254.28,89.86)
  TOP w0.112: v2(138.11,79.54) 137.6,79.54 RC243.1
  IN2 w0.124: v2(257.1,69.48) 256.94,69.33 251.23,69.33 249.12,67.22 247.62,67.22 245.33,64.93 245.33,63.48 243,61.15 243,60.17 242.07,59.23 236.35,59.23 235.15,58.04 228.71,58.04 227.68,59.07 219.23,59.07 218.87,59.43 216.39,59.43 215.28,58.32 208.22,58.32 207.57,58.97 206.68,58.97 206.04,59.61 203.95,59.61 201.81,61.75 182.45,61.75 182.16,62.04 174.15,62.04 170.7,65.49 162.58,65.49 159.06,69.01 150.48,69.01 150.06,69.43 149.68,69.43 147.12,71.99 147.12,72.37 145.01,74.48 145.01,77.94 v2(143.84,79.11)
  BOTTOM w0.076: UC1.AY15 123.55,91.53 123.55,91.25 123.44,91.14 123.44,89.28 125.42,87.3
  BOTTOM w0.112: v2(254.28,89.86) 254.69,90.27 256.1,90.27 256.37,90 256.37,86.9 257.26,86 257.26,85.37 258.24,84.39 258.24,81.56 257.82,81.13 257.82,79.81 256.95,78.94 256.95,77.32 257.68,76.59 257.68,75.65 256.97,74.94 256.97,73.46 257.88,72.54 257.88,70.27 v2(257.1,69.48) ; 125.42,87.3 v4(125.74,86.98) 126.26,86.46 126.26,85.75 127.72,84.29 127.72,82.08 131.05,78.75 135.86,78.75 136.65,79.54 v2(138.11,79.54) 141.27,79.54 142.14,78.67 142.14,78.5 142.54,78.09 143.41,78.09 143.84,78.52 v2(143.84,79.11)
ACAV_IN: length 309.8
  TOP w0.107: UE1.C7 v2(247.88,88.26)
  TOP w0.254: PR953.1 43.46,56.72 v2(43.52,56.78)
  IN1 w0.119: v2(245.02,112.16) 244.36,111.51 244.36,104.97 241.87,102.48 241.87,92.9 244.78,89.99 244.78,88.3 246.18,86.9 247.12,86.9 247.47,87.26 247.47,87.86 247.87,88.26 v2(247.88,88.26)
  IN2 w0.124: v2(236.54,82.32) 236.36,82.5 236.36,85.24 237.72,86.6 237.72,87.72 239.1,89.09 240.75,89.09 241.96,87.89 242.56,87.89 243.09,87.35 246.06,87.35 246.97,88.26 v2(247.88,88.26) ; v2(230.32,53.64) 230.18,53.51 226.3,53.51 225.79,54.02 214.14,54.02 213.78,53.66 204.5,53.66 203.99,53.15 203.1,53.15 202.68,53.57 202.68,55.48 200.03,58.13 196,58.13 195.32,58.81 183.71,58.81 183.4,58.5 183.4,58.04 182.35,56.98 180.11,56.98 179.4,57.69 178.19,57.69 176.1,55.6 164.73,55.6 162.99,57.34 145.53,57.34 v2(145.52,57.35)
  IN3 w0.135: v2(43.52,56.78) 44.54,56.78 44.98,57.22 50.33,57.22 53.03,54.52 58.61,54.52 59.07,54.06 60.63,54.06 62.48,55.92 69.77,55.92 71.83,53.86 72.62,53.86 75.26,51.22 135.79,51.22 138.63,54.06 143.86,54.06 145.52,55.72 v2(145.52,57.35)
  BOTTOM w0.112: v2(245.02,112.16) 244.03,112.16 240.81,115.38 240.81,117.56 241.34,118.09 241.34,121.91 238.13,125.12 238.13,126.77 238.8,127.44 238.8,129.94 238.56,130.19 RE530.2 237.97,130.5 237.97,131.15 238.07,131.25 QE13.4 ; v2(230.32,53.64) 230.69,54.02 231.16,54.02 233.05,55.91 233.05,57.14 235.76,59.85 235.76,62.2 235.43,62.53 235.43,65.19 234.95,65.67 234.95,67.17 234.78,67.34 234.78,70.12 235.19,70.52 235.19,79.72 235.99,80.52 235.99,81.77 v2(236.54,82.32)
  BOTTOM w0.254: v2(43.52,56.78) 43.27,56.53 v1(43.27,56.09) PR946.2
ACAV_IN1: length 8.6
  BOTTOM w0.203: PR925.1 53.75,56.58 PR918.1 PR928.1 52.87,55.71 52.45,55.29 52.45,54.85 51.91,54.31 PQ909.1 50.73,53.83
  BOTTOM w0.254: PR942.1 49.81,54.19 v1(50.16,53.83) 50.73,53.83
ACAV_IN_NB: length 376.3
  TOP w0.107: v2(257.4,88.23) 257.03,87.86 UE1.N6
  TOP w0.203: PR1206.2 v2(40.28,56.02) 40.28,56.22 PR1203.2 PC1207.1
  IN2 w0.124: v2(56.15,122.39) 57.3,123.54 60.15,123.54 62.94,126.33 67.94,126.33 68.52,126.91 74.5,126.91 74.75,126.66 80.03,126.66 83.45,130.08 104.31,130.08 104.83,129.56 108.04,129.56 108.54,130.06 117.63,130.06 118.79,131.23 124.03,131.23 124.46,130.8 124.46,130.39 125.02,129.83 126.4,129.83 127.02,130.44 130.14,130.44 131.07,131.37 134.62,131.37 135.91,132.66 141.63,132.66 144.68,129.61 146.84,129.61 147.28,129.17 147.28,127.65 148.4,126.53 155.12,126.53 161.37,120.28 161.37,119.52 161.99,118.9 161.99,110.13 166.63,105.49 166.63,90.5 168.99,88.13 168.99,85.57 171.36,83.21 171.36,80.52 181.36,70.52 185,70.52 186.73,68.79 206.04,68.79 207.31,67.52 222.25,67.52 222.91,68.18 226.01,68.18 226.63,68.8 228.04,68.8 231.12,71.88 232.9,71.88 234.22,73.19 235.14,73.19 236.19,74.24 236.19,75.23 236.84,75.88 236.84,76.53 237.2,76.89 238.34,76.89 239.09,76.15 240.92,76.15 242.05,75.02 249.19,75.02 249.55,74.66 250.52,74.66 251.32,75.46 255.38,75.46 255.58,75.66 258.29,75.66 259.11,74.84 260.81,74.84 262.38,76.41 262.38,80.12 262.18,80.33 262.18,83.11 261.71,83.58 259.14,83.58 257.75,84.97 257.75,86.1 257.4,86.45 v2(257.4,88.23)
  IN3 w0.135: v2(40.28,56.02) 40.38,56.02 41.6,54.8 43.6,54.8 44.92,53.48 v2(45.6,53.48)
  IN3 w0.254: v2(55.4,118.37) 55.1,118.08 55.1,116.27 53.57,114.73 53.57,111.12 54.85,109.84 54.85,99.22 52.86,97.23 48.54,97.23 47.88,96.57 47.88,92.57 46.57,91.26 46.57,89.23 44.64,87.3 44.64,83.07 40.94,79.37 40.94,77.63 39.2,75.89 39.2,64.65 40.28,63.57 v2(40.28,56.02)
  BOTTOM w0.112: v2(45.6,53.48) PR1258.1 PR1241.1 ; v2(55.4,118.37) 54.99,118.78 54.99,121.92 55.46,122.39 v2(56.15,122.39) 56.81,122.39 57.69,121.5 PR21.1
  BOTTOM w0.203: PR941.1 40.73,57.55 v1(40.61,57.44) 40.28,57.11 v2(40.28,56.02) 40.31,56.04 PU1201.1
ACIN_ISL88738: length 8.4
  TOP w0.127: PR944.2 50.58,62.89 v1(50.2,63.27)
  TOP w0.203: 53.76,57.83 53.96,57.64 PU901.19
  TOP w0.254: PR944.2 50.58,61.96 PR945.1 PC1286.1 52.06,59.57 52.06,58.41 52.63,57.83 53.76,57.83
ACOK_ISL88738: length 3.6
  TOP w0.112: v1(52.98,53.55) v2(52.98,54.11)
  TOP w0.203: PU901.24 54.13,55.64 53.91,55.42 53.91,55.04 v2(52.98,54.11)
  BOTTOM w0.203: PR928.2 v2(52.98,54.11)
ADP_ISL88738: length 3.8
  TOP w0.112: 54.51,60.59 54.51,60.78 53.35,61.94 v1(53.08,61.94)
  TOP w0.203: 54.51,60.59 54.79,60.31 54.79,59.73 55.12,59.39 PU901.16
ALW_PWRGD_3V_5V: length 38.8
  TOP w0.254: UZ6.2 203.73,59.07 204.21,58.58 204.21,57.08 v1(205.21,56.09) 205.54,55.76 v2(205.54,54.93)
  IN1 w0.254: v2(190.19,52.13) 190.77,51.55 195.9,51.55 197.23,52.88 203.49,52.88 v2(205.54,54.93)
  IN2 w0.254: v2(190.19,52.13) 185.9,52.13 184.71,53.33 180.06,53.33 178.33,55.05 v2(178.33,56.73)
  BOTTOM w0.254: v2(178.33,56.73) 178.37,56.69 PR119.2 179.04,56.7 PR120.2
ALWON: length 105.5
  TOP w0.107: UE1.A5 245.64,86.02 v2(245.02,86.02)
  TOP w0.112: v1(203,54.23) v2(203.4,53.82)
  IN2 w0.124: v2(203.4,53.82) 203.47,53.88 213.68,53.88 214.05,54.25 225.88,54.25 226.09,54.04 231.91,54.04 232.9,53.05 234.58,53.05 236.65,55.12 236.65,56.34 237.28,56.97 238.89,56.97 v2(239.3,56.57)
  BOTTOM w0.112: v2(239.3,56.57) 239.3,57.07 244.75,62.53 244.75,65.42 245.41,66.08 245.41,67.27 245.18,67.5 245.18,68.03 244.98,68.24 244.98,68.97 245.97,69.96 245.97,70.65 247.11,71.78 247.11,75.09 245.87,76.33 245.87,77.26 246.47,77.87 246.47,80.02 245.2,81.29 245.2,82.24 244.47,82.97 244.47,83.5 244.89,83.92 244.89,84.83 245.02,84.96 v2(245.02,86.02) ; PR114.1 183.01,60.58 PD100.2 183.72,60.86 185.05,62.19 200.35,62.19 201.26,61.29 201.26,58.41 203.4,56.26 v2(203.4,53.82)
AR_DET#: length 7.7
  BOTTOM w0.076: UC1.P4 130.76,106.12 131.99,106.12 132.44,106.34 133.25,106.34 134.3,107.39 v1(135.15,107.39) RC400.1 RC401.1
AR_DP1_CTRL_CLK: length 27.2
  TOP w0.076: 33.67,95.41 33.67,95.43 33.65,95.44 33.65,95.85 33.29,96.21 33.29,96.77 UT1.Y2
  TOP w0.112: RT125.1 RT13.1 v2(35.33,93.42) 35.01,93.74 35.01,94.24 34.43,94.82 34.08,94.82 33.67,95.23 33.67,95.41 ; v2(18.21,89.44) 18.11,89.34 QV3.1
  IN1 w0.119: v2(18.21,89.44) 18.62,89.04 19.65,89.04 20.18,89.57 25.07,89.57 26.17,90.67 26.17,91.18 26.7,91.71 34.09,91.71 35.01,92.63 35.01,93.1 v2(35.33,93.42)
AR_DP1_CTRL_DATA: length 24.2
  TOP w0.076: 33.43,95.41 33.43,95.43 33.45,95.44 33.45,95.76 33.09,96.12 33.09,96.5 UT1.Y1
  TOP w0.112: QV3.4 v2(19.41,89.47) ; RT124.1 RT12.1 v2(34.44,93.42) 34.77,93.74 34.77,94.14 34.33,94.58 33.98,94.58 33.43,95.13 33.43,95.41
  IN1 w0.119: v2(34.44,93.42) 34.76,93.1 34.76,92.73 33.99,91.96 26.6,91.96 25.92,91.28 25.92,90.78 24.97,89.82 20.08,89.82 19.73,89.47 v2(19.41,89.47)
AR_DP1_HPD: length 13.2
  TOP w0.076: 26.9,94.88 26.77,95.01 26.77,95.99 27.06,96.28 UT1.G1
  TOP w0.112: 26.9,94.88 28.46,93.32 28.46,91.22 28.1,90.87 27.8,90.87 27.43,90.5 v2(27.01,90.5)
  BOTTOM w0.102: v1(22.63,90.94) 22.96,90.61 QV5.3
  BOTTOM w0.112: QV5.3 24.84,89.99 RV20.1 26.64,90.13 v2(27.01,90.5)
AR_DP1_N0: length 23.3
  TOP w0.076: 30.67,95.41 30.73,95.46 30.73,95.83 30.74,95.84 30.74,96.17 30.69,96.21 30.55,96.21 30.5,96.27 30.5,96.69 30.57,96.77 30.66,96.77 30.74,96.69 UT1.R1
  TOP w0.112: 30.67,95.41 30.67,94.75 v2(30.79,94.63)
  IN3 w0.135: v2(22.54,81.27) 22.55,81.27 22.85,80.97 22.94,80.97 23.37,81.41 23.52,81.41 25.52,83.41 25.52,86.09 27.49,88.05 27.49,91.24 28.03,91.78 29.82,91.78 30.31,92.28 30.55,92.28 30.95,92.68 30.95,93.6 30.85,93.7 30.85,94.07 30.79,94.14 v2(30.79,94.63)
  BOTTOM w0.112: CV32.1 21.62,81.07 21.76,81.07 CT201.2 22.15,81.07 22.34,81.07 v2(22.54,81.27)
AR_DP1_N1: length 20.5
  TOP w0.076: UT1.N1 29.82,96.69 29.74,96.77 29.65,96.77 29.58,96.69 29.58,96.27 29.63,96.21 29.77,96.21 29.82,96.17 29.82,95.87 29.93,95.76 29.93,95.41
  TOP w0.112: v2(29.68,94.6) 29.93,94.85 29.93,95.41
  IN3 w0.135: v2(22.47,83.13) 22.47,83.11 22.69,82.88 22.85,82.88 23.07,83.1 23.07,83.94 23.84,84.7 23.84,85.77 24.41,86.35 24.41,87.75 26.26,89.6 26.26,91.55 27.32,92.61 28.77,92.61 29.93,93.77 29.93,94.05 29.79,94.19 29.79,94.48 v2(29.68,94.6)
  BOTTOM w0.112: v2(22.47,83.13) 22.3,82.97 22.1,82.97 CT202.2 21.79,82.94 21.59,82.94 CV34.1
AR_DP1_N2: length 17
  TOP w0.076: UT1.L1 28.9,96.69 28.82,96.77 28.72,96.77 28.66,96.71 28.66,96.28 28.73,96.21 28.84,96.21 28.92,96.14 28.92,95.57 28.84,95.49 28.84,95.41
  TOP w0.112: v2(28.66,94.82) 28.82,94.98 28.84,95 28.84,95.41
  IN3 w0.135: v2(22.49,86.84) 22.49,86.79 22.79,86.49 23,86.49 23.14,86.62 23.14,87.73 24.42,89.01 24.42,91.8 25.86,93.24 26.81,93.24 26.91,93.34 28.47,93.34 28.6,93.47 28.6,94.76 v2(28.66,94.82)
  BOTTOM w0.112: v2(22.49,86.84) 22.25,86.6 22.15,86.6 CT203.2 21.8,86.64 21.58,86.64 CV36.1
AR_DP1_N3: length 19.6
  TOP w0.076: 28.04,95.41 28.04,96.12 28.03,96.14 28.03,96.22 28.08,96.28 28.15,96.28 28.23,96.35 28.23,96.69 28.14,96.77 28.07,96.77 27.98,96.69 UT1.J1
  TOP w0.112: v2(28.09,95.16) 28.04,95.21 28.04,95.41
  IN3 w0.135: v2(28.09,95.16) 28.07,95.13 28.01,95.13 27.69,94.81 27.49,94.81 27.24,94.56 24.92,94.56 23.28,92.92 23.28,88.76 21.48,86.97 21.48,84.88 21.73,84.62 22.21,84.62 22.54,84.95 v2(22.54,84.95)
  BOTTOM w0.112: v2(22.54,84.95) 22.34,84.76 22.15,84.76 CT204.2 21.78,84.77 21.6,84.77 CV38.2
AR_DP1_P0: length 23.3
  TOP w0.076: 30.97,95.41 30.97,96.31 30.97,96.31 30.97,96.79 30.75,97.01 UT1.R2
  TOP w0.112: 30.97,95.41 30.97,95.03 31.23,94.77 31.23,94.26 v2(31.24,94.25)
  IN3 w0.135: v2(22.54,80.68) 22.72,80.68 22.73,80.69 23.05,80.69 23.49,81.12 23.64,81.12 25.81,83.29 25.81,85.97 27.77,87.94 27.77,91.12 28.15,91.5 29.94,91.5 30.41,91.97 30.64,91.97 31.24,92.56 31.24,93.72 31.14,93.81 31.14,94.16 v2(31.24,94.25)
  BOTTOM w0.112: CV31.1 21.55,80.81 21.83,80.81 CT201.1 22.08,80.81 22.41,80.81 v2(22.54,80.68)
AR_DP1_P1: length 20.5
  TOP w0.076: UT1.N2 29.83,97.01 30.05,96.79 30.05,95.96 30.17,95.84 30.17,95.77 30.19,95.75 30.19,95.74
  TOP w0.112: 30.19,95.74 30.19,94.42 30.21,94.39 v2(30.21,94.37)
  IN3 w0.135: v2(30.21,94.37) 30.21,93.65 28.89,92.32 27.44,92.32 26.55,91.43 26.55,89.48 24.69,87.63 24.69,86.23 24.12,85.66 24.12,84.59 23.35,83.82 23.35,82.98 22.9,82.52 v2(22.47,82.52)
  BOTTOM w0.112: v2(22.47,82.52) 22.28,82.7 22.14,82.7 CT202.1 21.77,82.71 21.61,82.71 CV33.1
AR_DP1_P2: length 17
  TOP w0.076: UT1.L2 28.91,97.01 29.15,96.77 29.15,95.45 29.1,95.41
  TOP w0.112: 29.1,95.41 29.1,94.44 v2(29.09,94.43)
  IN3 w0.135: v2(29.09,94.43) 29.08,94.43 28.88,94.24 28.88,93.35 28.58,93.05 27.03,93.05 26.93,92.96 25.98,92.96 24.71,91.68 24.71,88.89 23.42,87.61 23.42,86.51 23.12,86.21 v2(22.47,86.21)
  BOTTOM w0.112: CV35.1 21.59,86.37 21.79,86.37 CT203.1 22.09,86.34 22.34,86.34 v2(22.47,86.21)
AR_DP1_P3: length 19.6
  TOP w0.076: 27.79,95.51 27.81,95.53 27.81,96.03 27.75,96.09 27.75,96.78 27.98,97.01 UT1.J2
  TOP w0.112: v2(27.51,95.27) 27.56,95.27 27.79,95.51
  IN3 w0.135: v2(22.53,84.34) 21.61,84.34 21.2,84.76 21.2,87.08 22.99,88.88 22.99,93.04 24.8,94.85 27.09,94.85 v2(27.51,95.27)
  BOTTOM w0.112: CV37.2 21.6,84.54 21.78,84.54 CT204.1 22.08,84.49 22.38,84.49 v2(22.53,84.34)
AUD_HP_NB_SENSE: length 73.7
  TOP w0.254: v2(254.63,68.41) 254.67,68.45 RA60.2
  BOTTOM w0.254: JHP1.6 289.68,31.6 287.41,29.34 DA2.3 282.94,28.51 v3(280.5,28.51) 280.31,28.51 277.04,31.79 277.04,52.31 272.44,56.91 271.35,56.91 267.74,60.51 267.74,65.57 267.16,66.15 262,66.15 259.28,63.43 257.48,63.43 257.02,63.89 255.34,63.89 254.99,64.25 254.99,65.49 254.63,65.85 v2(254.63,68.41)
AUD_HP_OUT_L: length 41.1
  TOP w0.381: v2(258.34,50.68) v3(258.34,52.59) RA7.2 RA57.2 ; RA55.1 v2(281.32,37.6)
  IN3 w0.381: v2(258.34,50.68) 265.25,50.68 269.12,54.56 272.07,54.56 281.32,45.31 v2(281.32,37.6)
AUD_HP_OUT_L1: length 11.3
  TOP w0.102: RA55.2 v3(282.23,38.21)
  TOP w0.381: RA55.2 CA3.1 283.09,37.23 v2(282.73,37.6)
  BOTTOM w0.381: v2(282.73,37.6) 283.03,37.3 DA1.2 283.83,39.66 285.8,41.63 286.97,41.63 JHP1.1
AUD_HP_OUT_R: length 47.7
  TOP w0.381: RA58.2 256.69,53.97 256.69,51.19 v3(257.35,50.53) 257.83,50.05 v2(259.23,50.05) RA8.2 ; RA56.1 v2(281.32,35)
  IN3 w0.381: v2(259.23,50.05) 265.57,50.05 269.44,53.92 271.75,53.92 280.61,45.07 280.61,35.71 v2(281.32,35)
AUD_HP_OUT_R1: length 15.7
  TOP w0.381: v2(282.79,35) 283.09,35.3 CA2.1 RA56.2 ; JHP1.2 292.1,30.69 286.16,30.69 283.83,33.02 v3(283.83,33.35) v2(283.83,34.45)
  BOTTOM w0.381: v2(283.83,34.45) DA1.3 283.16,35.37 v2(282.79,35)
AUD_NB_MUTE#: length 77.6
  TOP w0.107: UE1.A4 245.76,85.33 244.52,85.33 244.35,85.51 v2(243.94,85.51)
  TOP w0.112: DA8.1 262.79,69.38 262.6,69.19 v2(262.38,69.19) 262.08,69.49 RA48.1
  IN2 w0.124: v2(266.23,95.96) 264.88,94.61 264.88,86.74 265.22,86.4 265.22,84.77 266.82,83.18 266.82,79.07 266.09,78.35 266.09,74.92 262.22,71.05 262.22,69.35 v2(262.38,69.19)
  BOTTOM w0.112: v2(243.94,85.51) 243.81,85.63 243.81,87.26 244.05,87.5 244.05,97.92 243.48,98.49 243.48,99.76 244.23,100.51 250.53,100.51 251.18,101.15 252.37,101.15 253.76,102.54 260.36,102.54 260.93,101.97 260.93,101.31 261.8,100.44 263.74,100.44 264.1,100.09 264.1,98.44 266.23,96.3 v2(266.23,95.96)
AUD_PC_BEEP: length 5.5
  TOP w0.112: UA1.16 253.87,61.34 252.84,62.37 252.3,62.37 CA27.2 CA28.2 250.91,62.74 v1(249.93,61.76)
AUD_PWR_EN: length 171.7
  TOP w0.112: UZ5.3 244.45,64.23 v2(244.25,64.03) 244.24,64.04 243.56,64.04 243.33,63.82 v1(243.33,63.56) 243.33,63.43 243.55,63.21 244.56,63.21 244.77,63.43 UZ5.5
  IN2 w0.124: v2(248.26,72.31) 245.38,72.31 244.61,71.54 243.3,71.54 242.76,70.99 242.22,70.99 240.24,69 237.01,69 236.55,68.54 235.24,68.54 232.85,66.16 230.88,66.16 230.35,66.68 227.63,66.68 226.26,65.31 205.97,65.31 204.62,66.66 185.91,66.66 184.14,68.43 179.85,68.43 175.53,72.75 171.48,72.75 170.73,73.5 170.73,77.83 169.25,79.32 169.25,82.29 166.88,84.66 166.88,87.25 163.29,90.83 154.06,90.83 151.74,93.15 151.74,98.82 149.58,100.98 147.73,100.98 147.45,100.7 146.58,100.7 144.8,102.47 144.8,102.7 144.56,102.94 144.56,105.4 v2(144.72,105.55)
  IN3 w0.135: v2(248.26,72.31) 248.26,72.15 247.45,71.33 247.45,70.01 247.01,69.58 247.01,66.81 244.25,64.05 v2(244.25,64.03) ; v2(144.72,105.55) 144.25,105.55 139.78,101.08 135.58,101.08 135.26,100.76 132.79,100.76 132.47,101.08 130.98,101.08 129.88,102.17 129.18,102.17 128.67,102.69 v2(128.67,102.71)
  BOTTOM w0.076: v2(128.67,102.71) 128.39,102.99 UC1.W8
  BOTTOM w0.112: RC279.1 145.36,106.11 144.8,105.55 v2(144.72,105.55)
AUD_SENSE_A: length 11.8
  TOP w0.127: v1(252.42,70.1) 252.89,69.63 RA59.2
  TOP w0.203: UA1.13 254.05,62.54 254.02,62.56
  TOP w0.254: 254.02,62.56 254.02,63.66 253.67,64.02 252.93,64.02 CA41.1 252.86,63.61 253.19,63.61 v2(253.34,63.46) ; v2(254.02,68.41) 253.76,68.68 RA60.1 RA59.2
  BOTTOM w0.254: v2(253.34,63.46) 253.34,65.92 254.02,66.61 v2(254.02,68.41)
AUD_SENSE_B: length 7.7
  TOP w0.112: UA1.14 253.67,62.14 v2(253.52,62.29) ; v1(253.14,67.64) 252.91,67.41 v2(252.91,67.12) 252.31,67.12 RA61.2
  BOTTOM w0.112: v2(253.52,62.29) 253.06,62.29 252.83,62.52 252.83,67.04 v2(252.91,67.12)
AUX_EN_WOWL: length 48.4
  TOP w0.107: v2(248.68,85.06) UE1.D3
  TOP w0.112: RZ70.1 252.63,107.12 251.17,105.66 RZ38.2 250.3,104.93 v1(250.2,104.82) 249.91,104.53 v2(249.91,103.9)
  IN1 w0.119: v2(259.54,102.09) 259.37,101.93 259.37,96.87 259.1,96.61 259.1,93.39 259.57,92.93 259.57,87.79 258.47,86.69 258.47,85 257.64,84.17 v2(256.7,84.17)
  IN2 w0.124: v2(249.91,103.9) 249.91,103.67 250.1,103.48 258.15,103.48 v2(259.54,102.09)
  IN3 w0.135: v2(256.7,84.17) 255.37,84.17 254.9,84.64 252.44,84.64 251.71,85.37 251.71,86.62 251.28,87.06 248.52,87.06 248.29,86.82 248.29,85.45 v2(248.68,85.06)
BAT1_LED#: length 131.6
  TOP w0.112: v2(287.55,11.38) 287.55,11 v1(287.81,10.74) ; UE1.D10 v2(248.68,91.46)
  IN2 w0.124: v2(255.97,94.94) 255.83,94.8 254.91,94.8 254.56,95.15 252.97,95.15 251.36,93.54 250.19,93.54 249.08,92.44 249.08,91.86 v2(248.68,91.46) ; v2(269.31,82.26) 270.46,82.26 273.05,79.66 273.05,75.79 274.93,73.92 278.46,73.92 279.39,72.99 279.39,72.96 280.12,72.23 281.41,72.23 283.27,70.37 283.27,63.04 282.29,62.06 282.29,56.48 280.02,54.2 280.02,31.62 288.14,23.51 288.14,13.36 287.04,12.27 287.04,11.89 v2(287.55,11.38)
  IN3 w0.135: v2(269.31,82.26) 268.88,82.69 268.88,88.67 269.87,89.66 269.87,96.66 265.3,101.23 264.41,101.23 264.11,100.93 260.73,100.93 259.94,100.14 258.9,100.14 256.46,97.7 256.46,95.44 v2(255.97,94.94)
  BOTTOM w0.112: RZ28.1 v2(287.55,11.38)
BAT2_LED#: length 57.5
  TOP w0.112: v2(269.7,86.23) 270.48,86.23 v1(270.98,85.73) QZ2.1 ; UE1.D11 v2(248.68,92.26) ; RZ361.1 242.55,93 v2(242.73,92.82)
  IN2 w0.124: v2(255.96,95.7) 251.79,95.7 248.68,92.6 v2(248.68,92.26)
  IN3 w0.135: v2(269.7,86.23) 269.15,86.78 269.15,88.5 270.18,89.53 270.18,96.76 265.35,101.59 264.31,101.59 264.11,101.38 263.09,101.38 262.63,101.84 259.92,101.84 259.46,101.38 259.46,100.75 259.1,100.39 257.76,100.39 255.37,98 255.37,96.29 v2(255.96,95.7) ; v2(242.73,92.82) 243.37,93.46 243.37,94.61 244.82,96.06 247.82,96.06 249.25,94.63 249.25,93.2 248.68,92.64 v2(248.68,92.26)
BAT2_LED#_R: length 91.9
  TOP w0.112: QZ2.3 271.6,83.24 271.87,83.51 271.87,84.08 272.33,84.54 QZ2.6 273.76,84.54 v2(273.77,84.53) ; v2(287.55,12.01) v1(288.28,12.01)
  IN2 w0.124: v2(287.55,12.01) 288.39,12.85 288.39,23.63 280.29,31.74 280.29,54.04 282.56,56.31 282.56,61.87 283.49,62.81 283.49,70.47 281.51,72.45 280.21,72.45 279.61,73.05 279.61,73.09 278.56,74.14 275.02,74.14 273.28,75.88 273.28,84.04 v2(273.77,84.53)
  BOTTOM w0.112: v2(287.55,12.01) 286.49,10.95 QZ3.2
BATT_WHITE#: length 168
  TOP w0.112: v2(239.93,92.72) 240.21,93 RZ361.2
  IN1 w0.119: v2(239.93,92.72) 239.75,92.72 238.55,93.93 238.55,103.12 242.78,107.35 243.04,107.35 243.58,107.89 243.58,110.73 v2(243.45,110.86)
  IN2 w0.124: v2(243.45,110.86) 243.93,110.86 248.46,106.32 255.86,106.32 256.51,105.67 259.36,105.67 261.91,103.12 263.61,103.12 267.93,98.8 268.71,98.8 272.59,94.92 272.59,91.67 272.06,91.13 272.06,89.72 271.45,89.11 270.52,89.11 267.95,86.55 267.58,86.55 267.42,86.39 267.42,85.37 268.56,84.24 268.56,80.87 269.11,80.32 270.59,80.32 271.99,78.91 271.99,75.35 275.44,71.9 278.94,71.9 279.68,71.17 280.97,71.17 282.17,69.97 282.17,63.67 281.17,62.67 281.17,56.93 278.52,54.28 278.52,53.88 277.56,52.91 277.56,30.57 284.9,23.23 284.9,11.97 284.61,11.68 v2(284.1,11.68)
  BOTTOM w0.112: v2(284.1,11.68) 284.1,10.84 QZ3.3 286.29,8.65 287.43,8.65 287.74,8.34 287.74,7.45 288.28,6.91 JLED1.3
