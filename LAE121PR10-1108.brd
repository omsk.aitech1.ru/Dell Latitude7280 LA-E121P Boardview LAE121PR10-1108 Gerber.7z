# Allegro board LAE121PR10-1108.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_ALWP on BOTTOM (solid shape): 199.03,58.62 199.03,54.6 200.18,53.45 200.18,52.33 194.21,52.33 193.83,52.72 193.83,58.43 194.14,58.75 198.91,58.75
+5V_PD_VDD on TOP (solid shape): 21.39,69.35 21.39,67.9 21.33,67.84 20,67.84 19.94,67.89 19.94,68.41 19.73,68.62 19.73,69.34 19.86,69.47 21.27,69.47
+5V_RUN on TOP (solid shape): 275.74,87.48 275.74,86.71 275.22,86.71 275.22,86.2 275.74,86.2 275.74,85.91 275.22,85.91 275.22,85.4 275.74,85.4 275.74,85.04 275.61,84.91 273.96,84.91 273.65,85.23 273.65,87.42 273.93,87.7 275.51,87.7
+5V_RUN on TOP (solid shape): 245.78,63.07 245.78,60.98 244.26,59.46 243.71,59.46 243.71,59.45 243.69,59.45 243.69,58.93 243.44,58.93 243.44,59.45 243.42,59.45 243.42,59.46 242.91,59.46 242.91,59.45 242.89,59.45 242.89,58.93 242.64,58.93 242.64,59.45 242.62,59.45 242.62,59.46 240.36,59.46 239.99,59.83 239.99,61.1 240.24,61.35 242.54,61.35 242.75,61.55 242.75,62.85 242.92,63.03 244.75,63.03 244.85,63.13 245.72,63.13
+5V_RUN on BOTTOM (solid shape): 19.77,91.26 19.77,90.5 19.65,90.37 17.69,90.37 17.22,90.84 17.22,91.35 17.32,91.45 19.58,91.45
+5V_RUN on BOTTOM (solid shape): 239.29,120.34 239.29,117.93 239.17,117.8 237.9,117.8 237.32,118.37 235.99,118.37 235.74,118.63 235.74,119.2 235.93,119.39 238.34,119.39 238.59,119.64 238.59,120.34 238.72,120.47 239.17,120.47
+5V_RUN on IN2 (solid shape): 35.9,65.35 35.9,64.78 35.65,64.53 33.68,64.53 33.17,65.03 33.17,65.54 35.71,65.54
+5V_RUN on IN2 (solid shape): 18.07,72.3 18.07,70.97 17.82,70.72 17.34,70.72 17.11,70.96 17.11,71.71 17.11,71.72 17.11,72.28 17.35,72.52 17.85,72.52
+5V_RUN on IN2 (solid shape): 240.05,117.61 240.05,117.1 239.93,116.98 239.29,116.98 238.78,117.49 238.21,117.49 238.02,117.68 238.02,118.25 238.15,118.37 239.29,118.37
+5V_RUN on IN2 (solid shape): 18.79,91.07 18.79,90.43 18.54,90.18 17.8,90.18 17.4,89.77 16.41,89.77 16.41,90.17 16.42,90.18 16.42,90.91 16.84,91.32 18.54,91.32
+5V_RUN on IN2 (solid shape): 25.61,67.45 25.61,66.69 24.98,66.69 23.96,67.7 23.07,67.7 22.88,67.89 22.88,68.53 23.01,68.65 24.41,68.65
+5V_RUN on IN2 (solid shape): 275.06,88.96 275.06,87.39 275.04,87.37 275.04,85.16 274.79,84.91 274.03,84.91 273.46,85.48 273.46,88.59 272.54,89.51 272.54,89.95 272.82,90.23 273.79,90.23
+5V_RUN on IN3 (solid shape): 18.4,71.83 18.4,70.81 17.38,70.81 17.28,70.91 17.28,71.77 17.41,71.89 18.33,71.89
+5V_RUN on IN3 (solid shape): 22.76,68.65 23.84,68.65 24.03,68.46 24.03,67.89 23.9,67.77 22.25,67.77 22,68.02 22,68.72 22.12,68.84 22.57,68.84
+5V_RUN on VCC: 203.14,57.35 202.25,58.24 171.52,58.24 169.67,60.08 156.59,60.08 151.83,64.84 58.57,64.84 58.06,64.34 55.14,64.34 54.63,64.84 34.48,64.84 34,65.33 34,66.37 143.72,66.37 144.36,67 152.26,67 156.76,62.49 162.14,62.49 162.77,61.86 237.37,61.86 248.22,72.72 263.08,72.72 265.31,74.94 268.29,74.94 268.82,75.47 268.82,77.31 272.69,81.19 272.69,90.14 273.31,90.75 276,90.75 276,81.02 275.3,80.32 275.3,78.98 273.2,76.89 273.2,69.52 271.44,67.77 259.61,67.77 257.96,69.42 249.79,69.42 245.03,64.65 243.82,64.65 243.1,63.93 243.1,62.6 242.4,61.9 242.4,61.86 242.34,61.8 242.34,60.4 239.29,57.35
+5V_RUN_AUDIO on TOP (solid shape): 265.9,64.08 265.56,63.75 264.27,63.75 263.72,64.3 262.9,64.3 262.82,64.38 262.82,65.51 262.88,65.57 264.29,65.57 264.95,66.23 265.89,66.23 265.9,66.24
+5V_RUN_AUDIO on TOP (solid shape): 248.06,59.89 248.06,57.29 249.07,56.27 249.83,56.27 249.9,56.21 249.9,54.81 248.88,54.81 246.98,56.72 245.13,56.72 244.63,57.22 242.07,57.22 241.95,57.35 241.95,59.19 242.07,59.32 242.51,59.32 242.51,58.8 243.02,58.8 243.02,59.32 243.31,59.32 243.31,58.8 243.82,58.8 243.82,59.32 246.72,59.32 246.85,59.45 246.85,59.89 246.98,60.02 247.93,60.02
+5V_RUN_AUDIO on IN1 (solid shape): outline of 821 points within 246.53,57.64 265.33,66.11
+5V_RUN_AUDIO on IN2 (solid shape): outline of 350 points within 246.79,57.67 265.28,65.72
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 248.06,63.06 248.63,63.06 248.75,62.93 248.75,62.11 246.72,60.08 246.72,59.51 246.47,59.51 246.47,60.08 245.96,60.08 245.96,59.51 245.71,59.51 245.6,59.61 245.6,60.62 247.04,62.05 247.04,63.07 247.1,63.13 247.98,63.13
+5V_RUN_PVDD_L on TOP (solid shape): 266.04,63.36 266.04,62.8 265.78,62.55 261.8,62.55 260.88,61.63 259.99,61.63 259.94,61.68 259.94,61.78 259.99,61.83 260.78,61.83 261.21,62.27 261.21,62.9 261.57,63.26 262.63,63.26 262.86,63.49 265.91,63.49
+5V_RUN_PVDD_L on TOP (solid shape): 261.34,59.62 262.86,59.62 263.07,59.83 264.51,59.83 264.59,59.75 264.59,58.91 264.49,58.81 263.5,58.81 263.37,58.94 263.37,59.24 263.27,59.35 262.66,59.35 262.61,59.29 262.23,59.29 262.2,59.32 261.26,59.32 260.96,59.62 259.97,59.62 259.92,59.68 259.92,59.78 259.97,59.83 261.14,59.83
+5V_RUN_PVDD_L on IN2 (solid shape): 266.11,63.13 266.11,62.55 265,61.43 265,58.99 264.77,58.76 263.7,58.76 263.45,59.02 263.45,62.37 264.39,63.31 265.94,63.31
+5V_RUN_UZ4 on TOP (solid shape): 277.52,90.18 277.52,89.61 277.9,89.23 277.9,88.97 278.28,88.59 278.28,85.01 278.17,84.9 275.99,84.9 275.88,85.01 275.88,85.51 275.87,85.51 275.87,85.53 275.36,85.53 275.36,85.53 275.36,85.78 275.87,85.78 275.87,85.8 275.88,85.8 275.88,86.31 275.87,86.31 275.87,86.33 275.36,86.33 275.36,86.57 275.36,86.58 275.87,86.58 275.87,86.6 275.88,86.6 275.88,88.77 275.76,88.89 275.76,89.78 275.88,89.89 276.03,89.89 276.38,90.24 277.46,90.24
+5V_USB_CHG_PWR on TOP (solid shape): 284.96,75.58 284.96,75.12 284.82,74.98 284.82,74.37 284.38,73.92 283.3,73.92 281.14,71.77 277.9,71.77 277.46,72.21 277.46,73.54 277.39,73.61 277.39,74.59 277.47,74.66 278.43,74.66 279.55,73.54 280,73.54 282.41,75.96 284.58,75.96
+5V_USB_CHG_PWR on BOTTOM (solid shape): 284.96,75.63 284.96,75.14 284.82,75 284.82,74.31 284.31,73.8 283.23,73.8 282.47,73.04 282.47,71.77 282.15,71.45 277.33,71.45 277.33,72.78 277.96,73.42 278.92,73.42 279.3,73.04 280.82,73.04 281.01,73.23 281.01,73.24 281.14,73.37 281.14,75.51 281.63,76.01 284.58,76.01
+DV33_18 on TOP (solid shape): 278.81,63.69 278.81,61.79 278.49,61.79 278.18,62.1 278.18,63.46 277.91,63.74 277.89,63.76 276.91,63.76 276.84,63.83 276.84,63.93 276.91,63.99 278.51,63.99
+VBUS_DC_SS on TOP (solid shape): 52.92,108.35 52.92,103.15 52.81,103.03 49.53,103.03 49.53,105.7 49.45,105.78 49.45,108.55 52.73,108.55
+VBUS_DC_SS on BOTTOM (solid shape): 52.92,106.12 52.92,102.88 52.79,102.75 47.75,102.75 47.75,104.38 47.97,104.6 51.08,104.6 51.33,104.85 51.33,106.18 51.46,106.31 52.73,106.31
+VCC_CORE on TOP (solid shape): outline of 498 points within 70.45,103.71 89.5,111.69
+VCC_CORE on TOP (solid shape): outline of 521 points within 106.98,96.43 114.65,114.46
+VCC_CORE on BOTTOM (solid shape): 77.49,111.44 77.49,104.72 77.18,104.4 67.65,104.4 67.33,104.72 67.33,106.94 69.87,106.94 69.87,107.77 67.4,107.77 67.4,110.37 68.72,111.69 77.24,111.69
+VCC_CORE on BOTTOM (solid shape): outline of 368 points within 79.87,104.16 89.31,109.99
+VCC_CORE on BOTTOM (solid shape): outline of 386 points within 108.69,96.46 114.41,99.43
+VCC_CORE on BOTTOM (solid shape): outline of 554 points within 107.64,106.95 114.86,109.81
+VCC_CORE on IN1 (solid shape): outline of 494 points within 108.23,100.4 114.39,106.25
+VCC_CORE on IN3 (solid shape): outline of 5188 points within 70.83,96.34 114.91,117.16
+VCC_CORE on VCC: 106.45,97.93 106.45,108.09 105.89,108.65 91.6,108.65 87.49,104.53 82.47,104.53 79.61,101.67 63.97,101.67 63.97,107.6 65.37,109 65.37,112.47 66.04,112.47 67.12,113.55 76.52,113.55 76.88,113.91 84.15,121.12 85.22,122.18 112.12,122.18 114.9,119.41 114.9,98.71 114.12,97.93
+VCC_CORE on IN2: 106.77,98.37 106.77,108.34 106.45,108.66 97.58,108.66 97.49,108.71 97.49,108.81 97.2,109.31 96.92,108.81 96.92,108.71 96.83,108.66 95.73,108.66 95.65,108.7 95.63,108.79 95.31,109.2 94.99,108.79 94.97,108.7 94.89,108.66 94.66,108.66 94.57,108.7 94.56,108.79 94.56,108.98 94.46,109.14 94.43,109.22 94.46,109.3 94.57,109.58 94.41,109.83 94.36,109.9 94.39,109.98 94.47,110.21 94.38,110.44 94.35,110.51 94.38,110.58 94.14,111.15 93.91,110.58 93.94,110.51 93.91,110.44 93.82,110.16 93.97,109.92 94.02,109.85 94,109.77 93.91,109.52 94.03,109.3 94.06,109.22 94.03,109.14 93.93,108.98 93.93,108.79 93.92,108.7 93.83,108.66 91.53,108.66 88.42,105.55 76.86,105.55 76.22,104.91 71.53,104.91 71.02,105.42 71.02,112.15 71.27,112.41 77.24,112.41 77.49,112.66 77.49,112.8 77.5,112.81 77.53,112.95 77.5,113.09 77.49,113.1 77.49,114.44 82.38,119.33 89.36,119.33 90.63,120.6 101.07,120.6 101.12,120.56 108.9,120.56 111.38,118.07 114.44,118.07 114.9,117.61 114.9,98.69 112.55,96.34 108.8,96.34
+VCC_GT on TOP (solid shape): outline of 4340 points within 70.13,86.18 106.98,114.44
+VCC_GT on BOTTOM (solid shape): 72.07,100.28 77.68,100.28 77.94,100.02 77.94,94.69 77.05,93.8 69.24,93.8 67.65,95.39 67.65,98.44 70.19,98.44 70.19,99.32 67.65,99.32 67.65,100.91 67.97,101.23 71.12,101.23
+VCC_GT on BOTTOM (solid shape): outline of 2394 points within 79.91,96.91 107.53,108.96
+VCC_GT on IN3 (solid shape): outline of 3363 points within 70.51,92.47 106.7,108.47
+VCC_GT on IN1: outline of 119 points within 74.94,92.47 105.93,106.68
+VCC_GT on VCC: 70,86.12 70,91.18 63.97,97.21 63.97,101.17 79.82,101.17 82.68,104.02 87.7,104.02 91.83,108.16 91.85,108.15 105.62,108.15 105.94,107.83 105.94,93.29 94.98,93.29 87.8,86.12
+VCC_GT on IN2: 73.75,94.37 73.54,94.58 73.54,100.34 74.38,101.17 79.91,101.17 82.76,104.02 88.67,104.02 92.8,108.15 105.67,108.15 105.92,107.9 105.92,97.61 105.69,97.38 90.68,97.38 89.46,98.6 89.46,98.62 89.37,98.94 89.05,99.04 89.02,99.04 88.73,99.32 82,99.32 81.72,99.05 81.71,99.04 81.5,98.94 81.4,98.73 81.39,98.72 77.05,94.37
+VCC_GTUS on BOTTOM (solid shape): outline of 887 points within 98.32,96.96 108.79,99.1
+VCC_SA on TOP (solid shape): 77.63,118.77 77.63,117.9 77.55,117.82 77.55,114.52 77.53,114.5 74.51,114.5 74,115.01 74,116.53 72.67,117.87 72.67,119.19 72.69,119.21 77.19,119.21
+VCC_SA on TOP (solid shape): 119.31,99.34 118.76,98.79 117.31,98.79 117.18,98.92 117.18,99.2 117.41,99.43 117.41,100.07 117.58,100.24 119.31,100.24
+VCC_SA on TOP (solid shape): 116.79,108.26 116.79,108.19 116.88,108.1 116.88,108.01 116.87,107.91 116.88,107.81 116.88,107.71 117.03,107.56 117.15,107.56 117.23,107.55 117.34,107.56 117.37,107.58 117.48,107.66 117.55,107.77 117.56,107.78 117.85,108.08 118.66,108.08 118.75,107.99 118.75,107.66 118.53,107.45 118.09,107.45 117.8,107.15 117.8,106.82 117.54,106.57 117.3,106.57 117.12,106.39 117.12,105.34 117.31,105.15 117.72,105.15 117.93,104.94 118.49,104.94 118.69,104.74 118.69,102.75 118.64,102.7 117.4,102.7 117.03,103.07 117.03,104.13 116.89,104.27 116.88,104.28 116.73,104.44 116.3,104.44 116.17,104.56 116.17,106.39 116.35,106.57 116.35,107.66 116.12,107.89 116.12,108.3 116.25,108.42 116.63,108.42
+VCC_SA on BOTTOM (solid shape): 77.81,118.44 77.81,114.18 77.43,113.8 74.07,113.8 73.81,114.06 73.81,115.19 75.12,115.19 75.12,115.99 73.81,115.99 73.81,117.49 73.28,118.02 73.28,119.14 73.34,119.2 77.05,119.2
+VCC_SA on BOTTOM (solid shape): 118.94,99.2 118.94,98.35 118.91,98.28 118.91,98.21 118.63,98.19 118.54,97.92 118.11,97.92 117.87,98.25 117.62,97.92 117.53,97.92 117.26,98.2 117.26,98.48 117.18,98.56 117.18,99.13 117.4,99.35 118.78,99.35
+VCC_SA on BOTTOM (solid shape): outline of 334 points within 114.92,107 119.38,109.81
+VCC_SA on VCC: 115.28,98.82 115.28,119.41 115.34,119.48 115.34,119.69 112.33,122.69 85.01,122.69 83.79,121.48 76.31,114.06 67.27,114.06 67.27,118.78 69.68,121.19 69.68,124.28 78.81,124.28 81.18,126.65 81.66,127.14 121.12,127.14 121.12,120.55 119.47,118.9 119.47,113.88 118.45,112.87 118.45,106.33 118.13,106.01 118.13,98.96 117.99,98.82 ; 1 cut-out
+VCC_SA on IN2: 117.18,98.81 115.85,100.14 115.85,109.61 116.1,109.87 116.91,109.87 117.14,109.64 117.14,109.08 118.13,108.09 118.13,98.94 118,98.81
+VCC_SFR_OC on TOP (solid shape): 137.25,71.36 137.25,69.63 137.36,69.52 137.36,69.17 137.22,69.04 134.33,69.04 134.33,69.54 134.39,69.61 135.66,69.61 135.85,69.8 135.85,70.41 135.71,70.54 135.48,70.54 135.39,70.64 135.39,71.29 135.54,71.45 137.16,71.45
+VCC_SFR_OC on IN2 (solid shape): 119.79,98.23 119.79,95.95 119.68,95.85 118.87,95.85 118.65,96.07 118.64,96.1 118.64,96.62 118.65,96.65 118.66,96.71 118.65,96.74 118.98,96.74 118.98,96.68 118.99,96.63 119.01,96.58 119.03,96.54 119.06,96.5 119.1,96.46 119.14,96.43 119.19,96.4 119.24,96.39 119.29,96.38 119.34,96.38 119.39,96.39 119.44,96.4 119.49,96.43 119.53,96.46 119.57,96.5 119.6,96.54 119.62,96.58 119.64,96.63 119.64,96.68 119.64,96.74 119.64,96.79 119.62,96.84 119.6,96.88 119.57,96.93 119.53,96.96 119.49,96.99 119.44,97.02 119.39,97.03 119.34,97.04 119.29,97.04 119.24,97.03 119.19,97.02 119.14,96.99 119.1,96.96 119.06,96.93 119.03,96.88 119.01,96.84 118.99,96.79 118.98,96.74 118.65,96.74 118.65,96.77 118.64,96.8 118.64,98.18 118.92,98.46 119.56,98.46
+VDDA_AVDD1 on TOP (solid shape): 254.41,56.3 254.86,56.3 254.91,56.35 254.99,56.35 255.01,56.32 255.01,56.14 254.51,55.64 250.28,55.64 250.21,55.7 250.21,56.45 250.37,56.6 254.1,56.6
+VSS_PLL on TOP (solid shape): 251.66,83.93 251.66,82.81 251.29,82.45 251.29,82.39 251.29,82.38 251.27,82.26 251.29,82.13 251.29,82.12 251.29,81.81 251.29,81.8 251.27,81.67 251.29,81.55 251.29,81.54 251.29,80.85 251.42,80.72 251.71,80.72 251.76,80.67 251.76,79.75 251.73,79.72 250.93,79.72 250.82,79.82 250.82,82.69 251.31,83.17 251.31,83.93 251.41,84.03 251.56,84.03
GND on TOP (solid shape): 68.41,104.72 68.22,104.53 66.25,104.53 66.06,104.72 66.06,107.96 68.41,107.96
GND on TOP (solid shape): 77.18,119.58 76.99,119.39 72.86,119.39 72.67,119.58 72.67,120.6 77.18,120.6
GND on TOP (solid shape): 10.12,45.48 10.12,44.14 8.85,44.14 8.6,44.4 8.6,45.54 8.79,45.73 9.87,45.73
GND on TOP (solid shape): 24.47,78.75 24.47,77.29 23.2,77.29 22.85,77.64 22.85,78.46 23.2,78.81 24.41,78.81
GND on TOP (solid shape): 149.57,128.79 149.57,127.01 148.42,127.01 148.23,127.2 148.23,128.79 148.36,128.92 149.44,128.92
GND on TOP (solid shape): 236.94,108.72 236.75,108.53 235.86,108.53 235.86,111.26 236.43,111.83 236.43,112.09 236.94,112.09
GND on TOP (solid shape): 247.29,107.83 247.29,107.14 247.04,106.88 244.63,106.88 244.63,107.77 244.94,108.09 247.04,108.09
GND on TOP (solid shape): 154.63,61.71 154.63,59.62 154.13,59.62 154.13,61 153.69,61.43 153.69,61.66 153.82,61.78 154.56,61.78
GND on TOP (solid shape): 178.05,50.81 178.05,49.56 177.97,49.48 174.84,49.48 174.77,49.56 174.77,50.81 175.02,51.07 177.79,51.07
GND on TOP (solid shape): 201.29,51.73 201.29,50.56 201.1,50.37 197.12,50.37 196.92,50.57 196.92,51.81 197.1,51.99 201.03,51.99
GND on TOP (solid shape): 258.85,68.97 258.85,67.96 256.63,67.96 256.18,68.4 256.18,69.04 257.44,69.04 257.5,69.1 258.72,69.1
GND on TOP (solid shape): 267.42,65.86 267.42,62.88 267.11,62.56 266.22,62.56 266.22,64.65 266.15,64.72 266.15,66.18 267.11,66.18
GND on TOP (solid shape): 278,71.21 278,69.91 277.87,69.78 276.73,69.78 276.64,69.87 276.64,71.35 276.73,71.44 277.77,71.44
GND on TOP (solid shape): 32.03,88.47 32.03,87.58 32.35,87.26 33.55,87.26 33.55,86.75 31.2,86.75 30.89,87.07 30.89,88.47 31.01,88.59 31.9,88.59
GND on TOP (solid shape): 121.5,126.06 121.82,126.06 121.94,125.93 121.94,125.68 121.37,125.11 120.55,125.11 120.36,125.3 120.36,126.12 120.48,126.25 121.31,126.25
GND on TOP (solid shape): 130.07,82.05 129.98,81.96 129.6,81.96 129.15,82.42 128.69,82.42 128.57,82.54 128.57,83.16 128.68,83.26 128.68,83.77 130.07,83.77
GND on TOP (solid shape): 170.38,78.37 170.38,74.66 169.58,73.86 167.92,73.86 167.73,74.05 167.73,78.43 168.05,78.75 170,78.75
GND on TOP (solid shape): 240.82,80.15 240.8,80.13 240.8,77.75 240.68,77.63 239.5,77.63 239.2,77.93 239.2,80.25 240.05,81.1 240.82,81.1
GND on TOP (solid shape): 21.39,67.45 21.39,66.66 21.65,66.39 21.65,66.03 20.98,65.35 19.9,65.35 19.9,67.42 19.98,67.5 21.33,67.5
GND on TOP (solid shape): 60.95,133.97 60.95,133.12 60.87,133.04 59.4,133.04 59.18,133.26 58.18,133.26 58.01,133.42 58.01,134.08 58.14,134.21 60.7,134.21
GND on TOP (solid shape): 67.64,117.28 67.64,116.85 67.51,116.72 66.45,116.72 66.27,116.55 66.27,115.66 63.98,115.66 63.78,115.86 63.78,116.97 64.22,117.41 67.51,117.41
GND on TOP (solid shape): 76.1,90.43 76.1,88.4 75.08,87.39 70.57,87.39 70,87.96 70,90.31 70.32,90.63 75.91,90.63
GND on TOP (solid shape): 95.59,53.29 96.16,52.72 96.16,52.33 96.04,52.21 92.92,52.21 92.73,52.4 92.73,53.03 92.8,53.1 92.8,55.45 95.59,55.45
GND on TOP (solid shape): 126.96,80.02 127.21,79.77 127.23,79.77 127.33,79.67 129.35,79.67 129.48,79.54 129.48,79.13 128.84,78.5 126.45,78.5 126.45,80.72 126.96,80.72
GND on TOP (solid shape): 207.86,51.19 208.05,51 208.94,51 209.07,50.87 210.78,50.87 210.78,50.43 210.53,50.18 207.73,50.18 207.03,50.87 207.03,52.33 207.86,52.33
GND on TOP (solid shape): 50.32,131.77 50.32,129.36 50.25,129.3 49.74,129.3 49.62,129.42 49.62,131.77 49.81,131.96 50.13,131.96
GND on TOP (solid shape): 164.29,88.23 164.29,85.74 164.21,85.66 163.1,85.66 162.99,85.77 162.99,88.1 163.17,88.28 164.24,88.28
GND on TOP (solid shape): 254.08,65.55 255.07,65.55 255.15,65.47 255.15,64.58 254.9,64.32 253.03,64.32 252.91,64.45 252.91,65.84 253,65.92 253.71,65.92
GND on TOP (solid shape): 275.14,92.54 275.14,90.21 275.59,89.76 275.59,89.43 275.52,89.36 274.47,89.36 274.02,89.81 274.02,92.43 274.19,92.61 275.07,92.61
GND on TOP (solid shape): 69.68,56.59 70.26,56.59 70.32,56.53 70.32,55.83 70.19,55.7 66,55.7 65.78,55.92 65.78,56.81 65.89,56.91 69.37,56.91
GND on TOP (solid shape): 126.39,125.93 126.39,124.94 126.27,124.82 124.9,124.82 124.61,124.53 124.17,124.53 124.17,124.98 124.67,125.49 124.67,126.06 126.26,126.06
GND on TOP (solid shape): 273.65,127.71 273.65,127.33 273.52,127.2 273.2,127.2 272.44,127.96 271.11,127.96 270.34,128.73 268.69,128.73 268.69,129.04 268.76,129.11 272.25,129.11
GND on TOP (solid shape): 282.47,65.35 282.47,65.34 282.57,65.24 282.57,64.43 282.47,64.32 281.55,64.32 281.49,64.37 281.49,64.9 281.05,65.34 281.05,66.03 281.2,66.18 281.65,66.18
GND on TOP (solid shape): 38.33,57.01 38.33,54.65 38.45,54.52 39.01,54.52 39.01,52.54 38.89,52.41 38.61,52.41 38.51,52.51 38.51,53.48 38.02,53.96 37.29,53.96 37.26,53.99 37.26,57.19 38.15,57.19
GND on TOP (solid shape): 139.34,71.13 139.34,69.04 139.53,68.84 139.53,68.34 139.03,68.34 138.33,69.04 137.82,69.04 137.82,69.04 137.74,69.04 137.63,69.16 137.63,69.67 137.5,69.8 137.5,71.26 137.6,71.35 139.12,71.35
GND on TOP (solid shape): 158.01,58.81 157.38,58.18 156.67,58.18 156.51,58.33 156.13,58.33 155.98,58.18 155.32,58.18 155.32,58.53 156.08,58.53 156.41,58.86 156.97,58.86 157.12,59.02 157.12,60.77 158.01,60.77
GND on TOP (solid shape): 210.06,57.21 210.06,56.75 210.05,56.75 210.05,55.16 209.9,55.01 208.34,55.01 208.2,55.15 208.2,55.56 208.3,55.66 208.89,55.66 209.08,55.85 209.08,57.21 209.17,57.3 209.97,57.3
GND on TOP (solid shape): 250.79,65.99 250.79,64.46 250.4,64.08 250.4,62.53 249.91,62.04 249.2,62.04 249.01,62.23 249.01,62.81 249.39,63.19 249.39,64.78 249.01,65.16 249.01,65.73 249.33,66.05 250.72,66.05
GND on TOP (solid shape): 267.8,58.24 267.8,54.49 266.79,53.48 264.5,53.48 263.8,54.18 263.8,54.99 263.85,55.04 264.39,55.04 265.07,54.37 266.09,54.37 266.28,54.56 266.28,56.14 266.72,56.59 266.72,58.68 266.85,58.81 267.23,58.81
GND on TOP (solid shape): 63.88,131.39 63.89,131.38 63.96,131.28 64.06,131.21 64.07,131.2 64.16,131.11 64.16,128.46 64.03,128.33 63.5,128.33 62.94,128.89 62.94,130.88 62.51,131.31 62.51,131.87 62.69,132.05 63.23,132.05
GND on TOP (solid shape): 68.92,75.45 68.92,75.39 69.37,74.94 69.37,71.45 68.92,71 66.95,71 66.83,71.13 66.83,72.65 67.4,73.23 67.4,74.81 67.78,75.19 67.78,75.64 68.73,75.64
GND on TOP (solid shape): 240.73,63.72 240.73,61.56 240.67,61.5 239.74,61.5 239.69,61.55 239.69,61.57 239.57,61.91 239.34,62.19 239.34,63.76 239.5,63.92 240.54,63.92
GND on TOP (solid shape): 244.64,82.46 244.64,82.28 244.08,81.72 244.08,81.1 243.84,80.86 243.84,80.25 243.78,80.19 243.09,80.19 243.04,80.23 243.04,81.16 243.04,81.17 243.04,81.39 243.22,81.57 243.22,82.28 243.36,82.42 244,82.42 244.21,82.62 244.47,82.62
GND on TOP (solid shape): 59.5,110.31 59.5,103.78 58.89,103.18 57.13,103.18 56.76,102.81 55.91,102.81 55.65,103.07 55.65,105.87 55.15,106.37 55.15,109.55 55.14,109.56 55.14,110.37 55.52,110.75 59.05,110.75
GND on TOP (solid shape): 58.57,70.43 58.23,70.09 55.05,70.09 54.51,69.54 54.51,66.37 54.32,66.18 50.89,66.18 50.32,66.75 50.32,71.13 51.9,72.72 55.78,72.72 56.48,73.42 56.48,76.72 57.43,77.67 58.57,77.67
GND on TOP (solid shape): 124.04,83.39 123.79,83.13 123.79,82.31 123.86,82.24 124.68,82.24 124.8,82.36 124.8,82.75 124.99,82.94 125.25,82.94 125.36,82.83 125.36,82.14 125.08,81.86 124.48,81.86 124.17,81.54 123.53,81.54 123.47,81.61 123.47,81.99 122.2,83.26 121.75,83.26 121.69,83.32 121.69,83.77 121.75,83.83 124.04,83.83
GND on TOP (solid shape): 156.32,82.56 158.14,82.56 158.14,81.8 158.04,81.7 157.25,81.7 157.05,81.49 157.05,80.27 156.92,80.15 153.26,80.15 152.61,80.8 152.02,80.8 151.3,81.53 151.3,82.17 151.37,82.25 152.48,82.25 152.62,82.1 152.62,82.1 153.39,81.33 154.21,81.33 154.54,81.66 154.54,83.03 154.58,83.07 155.81,83.07
GND on TOP (solid shape): 282.92,55.76 282.92,54.94 282.76,54.78 282.45,54.78 282.34,54.89 282.21,54.97 282.16,54.99 281.89,55.04 281.63,54.99 280.73,54.99 280.59,55.13 280.59,55.81 280.77,55.99 282.69,55.99
GND on TOP (solid shape): 45.17,80.59 45.17,79.96 45.55,79.58 45.55,75.89 45.43,75.77 42.76,75.77 42.44,75.45 42.44,72.46 42.25,72.27 41.36,72.27 41.17,72.08 41.17,71.38 41.05,71.26 39.58,71.26 39.39,71.45 39.39,75.58 41.36,77.54 41.36,79.64 42.38,80.66 45.11,80.66
GND on TOP (solid shape): 65.06,94.12 67.41,94.12 68.1,93.43 68.1,91.22 67.83,90.94 64.29,90.94 63.91,90.56 59.97,90.56 59.84,90.69 59.84,91.15 59.67,91.32 59.67,93.38 59.83,93.54 60.56,93.54 60.79,93.77 60.79,94.37 60.92,94.5 64.68,94.5
GND on TOP (solid shape): 206.78,59.5 206.78,59.07 206.63,58.92 206.28,58.92 206.18,58.81 206.18,57.78 205.94,57.55 204.94,57.55 204.73,57.76 204.73,58.05 204.76,58.09 204.81,58.08 205.19,58.08 205.3,58.1 205.39,58.16 205.46,58.16 205.57,58.27 205.57,58.67 205.37,58.87 204.56,58.87 204.5,58.93 204.5,59.2 204.56,59.26 205.44,59.26 205.76,59.57 206.71,59.57
GND on TOP (solid shape): 153.22,76.34 157.19,76.34 157.44,76.08 157.44,75.26 157.12,74.94 155.85,74.94 155.22,74.31 153.63,74.31 153.12,74.81 152.3,74.81 152.11,74.62 152.11,73.8 152.61,73.29 152.61,72.29 152.42,72.1 151.2,72.1 150.96,72.34 150.96,76.35 151.13,76.52 153.05,76.52
GND on TOP (solid shape): 184.5,57.52 184.5,56.68 184.72,56.46 187.01,56.46 187.22,56.68 187.22,57.64 187.25,57.67 188.67,57.67 189.05,57.29 189.05,56.46 189.06,56.46 189.06,55.51 189,55.45 187.03,55.45 186.21,54.62 184.05,54.62 183.89,54.77 182.83,54.77 182.29,54.24 180.31,54.24 180.16,54.39 180.16,55.88 181.34,57.06 182.68,57.06 183.29,57.67 184.35,57.67
GND on TOP (solid shape): 55.33,131.54 55.33,130.38 55.73,129.98 56.13,129.98 56.18,129.92 56.18,128.94 55.9,128.66 55.9,127.15 55.85,127.1 55.18,127.1 55.08,127.2 55.08,128.79 54.88,128.99 54.44,128.99 54.37,129.07 54.37,129.68 54.46,129.77 54.53,129.78 54.75,130 54.75,130.99 54.57,131.16 53.73,131.16 53.55,131.34 53.55,131.84 53.62,131.9 54.98,131.9
GND on TOP (solid shape): 145.23,133.11 145.78,131.75 146.71,130.6 146.71,130.31 146.65,130.25 146.33,130.25 146.2,130.38 146.2,130.57 145.95,130.82 145.5,130.82 145.5,131.01 145.25,131.27 144.17,131.27 143.98,131.07 143.98,128.79 141.12,128.79 140.87,129.04 140.87,131.27 141.31,131.71 143.34,131.71 143.72,132.09 143.72,133.11
GND on TOP (solid shape): 226.51,57.95 226.51,57.52 226.87,57.16 228.88,57.16 229.08,56.96 229.08,55.92 228.94,55.78 227.76,55.78 227.49,55.52 227.49,54.15 227.1,53.75 223.09,53.75 222.93,53.91 222.93,54.67 223.06,54.8 223.58,54.8 223.77,54.99 223.77,56.08 223.89,56.2 224.29,56.2 224.34,56.15 224.34,55.78 224.22,55.65 224.22,54.89 224.35,54.75 225.96,54.75 226.09,54.88 226.09,55.65 225.96,55.78 225.76,55.78 225.72,55.82 225.72,56.8 225.47,57.04 224.69,57.04 224.32,57.41 224.32,57.92 224.53,58.14 226.32,58.14
GND on TOP (solid shape): 115.9,108.27 115.9,107.86 116.22,107.54 116.22,106.6 116.07,106.44 116.07,104.39 116.26,104.19 116.72,104.19 116.91,104 116.91,103.93 116.91,103.93 116.91,103.27 116.5,102.86 115.64,102.86 115.49,102.7 115.49,102.15 115.82,101.82 115.82,101.57 115.46,101.21 115.46,100.81 116.02,100.25 116.02,99.56 115.94,99.48 114.6,99.48 114.53,99.55 114.53,100.04 114.81,100.32 114.81,107.7 115.04,107.93 115.04,108.19 115.21,108.37 115.8,108.37
GND on TOP (solid shape): 108.1,105.61 108.1,105.23 108.23,105.1 108.74,105.1 108.86,105.23 108.86,105.61 108.99,105.74 109.24,105.74 109.37,105.61 109.37,105.23 109.5,105.1 110.01,105.1 110.13,105.23 110.13,105.61 110.26,105.74 110.51,105.74 110.64,105.61 110.64,105.23 110.77,105.1 111.28,105.1 111.4,105.23 111.4,105.61 111.53,105.74 111.78,105.74 111.91,105.61 111.91,105.23 112.04,105.1 112.55,105.1 112.67,105.23 112.67,105.61 112.8,105.74 113.05,105.74 113.18,105.61 113.18,105.23 113.31,105.1 113.69,105.1 113.69,104.47 107.72,104.47 107.72,105.1 107.59,105.23 107.59,105.61 107.72,105.74 107.97,105.74
GND on TOP (solid shape): 161.19,131.39 161.22,131.39 161.67,131 162.17,130.68 162.28,130.62 162.39,130.5 162.39,129.49 162.2,129.3 161.44,129.3 161.38,129.36 161.38,129.55 161.12,129.8 160.17,129.8 159.92,129.55 159.92,128.53 158.84,127.46 156.87,127.46 156.63,127.21 156.63,127.02 156.56,126.95 156.07,126.95 156.03,127 156.03,128.52 156.62,129.11 158.84,129.11 159.22,129.49 159.22,130.69 159.09,130.82 158.52,130.82 158.52,131.33 158.58,131.39 159.47,131.39 159.73,131.65 160.93,131.65
GND on TOP (solid shape): 150.18,62.94 150.42,62.94 150.54,62.81 150.54,58.02 150.82,57.75 151.43,57.75 151.43,57.24 149.99,57.24 149.99,58.2 149.76,58.43 147.98,58.43 147.65,58.76 147.64,58.76 147.63,58.77 147.6,58.77 147.59,58.78 147.44,58.81 147.29,58.78 147.28,58.77 146.73,58.77 146.7,58.81 146.7,59.34 146.73,59.37 147.5,59.37 147.77,59.1 147.8,59.06 147.84,59.03 147.98,58.89 148.92,58.89 149.06,59.03 149.06,60.76 149.45,61.15 149.45,62.3 148.78,62.98 147.7,62.98 147.57,63.1 147.57,63.88 147.82,64.12 149,64.12
GND on TOP (solid shape): 299.7,91.39 299.91,91.31 299.99,91.1 299.99,89.25 299.91,89.04 299.7,88.96 297.31,88.96 297.31,86.2 297.22,85.99 297.02,85.91 288.08,85.91 288.06,85.94 287.28,86.4 286.69,85.7 286.69,84.66 283.23,84.66 282.92,84.97 282.92,88.09 283.42,88.59 288.17,88.59 289.4,89.82 289.4,91.33 289.46,91.39
GND on TOP (solid shape): 108.1,103.2 108.1,102.82 108.23,102.69 108.74,102.69 108.86,102.82 108.86,103.2 108.99,103.33 109.24,103.33 109.37,103.2 109.37,102.82 109.5,102.69 110.01,102.69 110.13,102.82 110.13,103.2 110.26,103.33 110.51,103.33 110.64,103.2 110.64,102.82 110.77,102.69 111.28,102.69 111.4,102.82 111.4,103.2 111.53,103.33 111.78,103.33 111.91,103.2 111.91,102.82 112.04,102.69 112.55,102.69 112.67,102.82 112.67,103.2 112.8,103.33 113.05,103.33 113.18,103.2 113.18,102.82 113.31,102.69 113.69,102.69 113.69,101.04 113.31,101.04 113.18,100.91 113.18,100.53 113.05,100.4 112.8,100.4 112.67,100.53 112.67,100.91 112.55,101.04 112.04,101.04 111.91,100.91 111.91,100.53 111.78,100.4 111.53,100.4 111.4,100.53 111.4,100.91 111.28,101.04 110.77,101.04 110.64,100.91 110.64,100.53 110.51,100.4 110.26,100.4 110.13,100.53 110.13,100.91 110.01,101.04 109.5,101.04 109.37,100.91 109.37,100.53 109.24,100.4 108.99,100.4 108.86,100.53 108.86,100.91 108.74,101.04 108.23,101.04 108.1,100.91 108.1,100.53 107.97,100.4 107.72,100.4 107.59,100.53 107.59,103.2 107.72,103.33 107.97,103.33
GND on TOP (solid shape): 12.1,74.99 12.1,72.71 14.69,70.11 16.39,70.11 17.35,69.16 17.35,68.55 16.94,68.15 13.5,68.15 13.5,69.25 12.9,69.95 12.13,69.45 3.19,69.45 2.98,69.54 2.89,69.75 2.89,71.4 2.98,71.61 3.19,71.7 4.3,71.7 4.66,71.84 4.8,72.2 4.8,74.55 6.78,76.53 10.55,76.53
GND on TOP (solid shape): 34.12,44.72 33.48,49.52 38.25,48.65 38.17,48.65 38.06,48.63 37.96,48.56 37.74,48.34
GND on TOP (solid shape): 146.1,51.07 150.14,55.1 154.1,51 154.1,50.32 153.95,49.77 153.9,49.2 153.9,48.95 153.87,48.88 153.8,48.85 146.1,48.85
GND on TOP (solid shape): outline of 117 points within 0.61,95.81 10.32,104.66
GND on TOP (solid shape): 10.3,96.2 0.6,96.2 0.6,100.27 0.65,100.36 0.75,100.37 0.99,100.28 1.25,100.24 2.55,100.24 3.61,101.04 3.14,102.28 3.1,102.4 3.19,102.47 3.98,102.47 3.99,102.44 4.31,102.06 4.8,101.99 5.2,101.45 5.84,101.24 6.71,101.24 7.57,101.65 7.81,102.66 7.89,102.7 10.3,102.7
GND on TOP (solid shape): 10.3,111.6 7.84,111.6 7.8,111.61 7.77,111.63 7.59,112.61 6.71,113.06 5.84,113.06 5.2,112.85 4.8,112.31 4.31,112.24 3.99,111.86 3.98,111.83 3.09,111.83 3.02,111.86 2.99,111.94 3.63,113.18 2.55,114.06 1.25,114.06 0.94,114.01 0.66,113.88 0.62,113.92 0.6,113.97 0.6,115.1 0.69,115.31 0.9,115.4 1.3,115.4 1.66,115.54 1.8,115.9 1.8,117.6 1.89,117.81 2.1,117.9 10.3,117.9
GND on TOP (solid shape): 286.69,72.1 287.28,71.4 288.06,71.86 288.08,71.89 297.02,71.89 297.22,71.81 297.31,71.6 297.31,69.95 297.22,69.74 297.02,69.66 293.9,69.66 293.54,69.51 293.39,69.15 293.39,66.75 293.54,66.39 293.9,66.24 300.2,66.24 300.41,66.16 300.49,65.95 300.49,50.63 300.41,50.42 300.2,50.34 299.5,50.34 299,50.13 298.79,49.63 298.79,48.03 299,47.53 299.5,47.32 300.2,47.32 300.41,47.24 300.49,47.03 300.49,46.41 295.9,46.41 295.79,46.39 295.69,46.36 295.17,46.87 295.17,50.18 295.49,50.49 298.73,50.49 299.09,50.71 299.5,50.79 300.04,50.79 300.04,59.32 299.79,59.57 298.41,59.57 298.41,61.42 298.6,61.61 298.6,63.07 297.27,64.4 294.22,64.4 292.89,63.07 285.84,63.07 285.52,63.38 285.52,64.84 282.92,67.45 282.92,72.78 283.3,73.16 286.69,73.16
GND on TOP (solid shape): outline of 217 points within 140.92,55.41 144.75,64.27
GND on TOP (solid shape): outline of 236 points within 97.88,97.17 107.09,108.67
GND on TOP (solid shape): outline of 261 points within 1.81,35.31 17.39,56.86
GND on TOP (solid shape): outline of 92 points within 27.27,98.22 33.01,100.72
GND on TOP (solid shape): outline of 745 points within 30.32,0.21 299.29,52.97
GND on TOP (solid shape): outline of 1279 points within 0.61,71.84 299.99,136.99
GND on TOP (solid shape): outline of 2509 points within 16.18,94.12 34.11,106.36
GND on BOTTOM (solid shape): 149.57,127.01 148.36,127.01 148.17,127.2 148.17,128.85 148.42,129.11 149.57,129.11
GND on BOTTOM (solid shape): 24.66,67.13 24.66,66.3 22.95,66.3 22.88,66.37 22.88,67.38 23.07,67.57 24.22,67.57
GND on BOTTOM (solid shape): 236.57,88.1 236.57,85.71 233.91,85.71 233.88,85.74 233.88,87.92 234.19,88.23 236.45,88.23
GND on BOTTOM (solid shape): 22.31,52.46 22.31,51.7 22.12,51.51 20.92,51.51 20.79,51.64 20.79,52.46 20.92,52.59 22.19,52.59
GND on BOTTOM (solid shape): 76.1,92.91 76.1,90.05 75.72,89.67 73.49,89.67 73.05,90.12 73.05,92.97 73.18,93.1 75.91,93.1
GND on BOTTOM (solid shape): 143.05,120.56 143.05,118.77 142.98,118.7 142.1,118.7 141.97,118.83 141.97,120.68 142.92,120.68
GND on BOTTOM (solid shape): 176.86,58.53 176.86,58.38 176.3,57.82 175.67,57.82 174.73,58.76 174.73,59.42 175.31,60.01 175.39,60.01
GND on BOTTOM (solid shape): 199.19,60.25 199.19,59.08 198.98,58.88 196.24,58.88 195.86,59.26 195.86,60.46 198.97,60.46
GND on BOTTOM (solid shape): 281.58,70.43 281.58,68.78 281.52,68.72 276.88,68.72 276.82,68.78 276.82,70.43 277.2,70.81 281.2,70.81
GND on BOTTOM (solid shape): 74,88.28 74,86.43 73.3,85.74 70.38,85.74 70.38,88.59 70.45,88.66 73.62,88.66
GND on BOTTOM (solid shape): 75.91,100.72 71.88,100.72 71.58,101.03 71.58,102.8 71.91,103.13 75.91,103.13
GND on BOTTOM (solid shape): 8.51,38.64 8.51,36.4 8.41,36.3 7.22,36.3 7.07,36.45 7.07,38.49 7.27,38.69 8.46,38.69
GND on BOTTOM (solid shape): 11.62,45.37 11.62,43.2 11.51,43.08 9.72,43.08 8.6,44.21 8.6,45.54 8.72,45.67 11.33,45.67
GND on BOTTOM (solid shape): 30.19,126.5 30.19,124.85 30.12,124.79 27.2,124.79 26.82,125.17 26.82,126.5 26.95,126.63 30.06,126.63
GND on BOTTOM (solid shape): 32.31,38.49 32.31,36.46 32.16,36.31 30.96,36.31 30.86,36.41 30.86,38.64 30.91,38.7 32.1,38.7
GND on BOTTOM (solid shape): 77.56,67.52 74.06,67.52 73.98,67.61 73.98,69.03 73.46,69.56 73.46,70.37 74.09,71 74.09,72.07 77.56,72.07
GND on BOTTOM (solid shape): 111.96,122.78 112.02,122.72 112.02,119.5 111.93,119.42 111.44,119.42 111.35,119.51 111.35,122.65 111.48,122.78 111.89,122.78
GND on BOTTOM (solid shape): 130.71,125.3 130.26,125.3 130.07,125.11 130.07,124.15 129.95,124.03 128.8,124.03 128.68,124.15 128.68,125.42 128.93,125.68 130.71,125.68
GND on BOTTOM (solid shape): 134.33,131.27 134.33,128.41 134.07,128.15 132.87,128.15 132.42,128.6 132.42,129.8 133.06,130.44 133.06,131.46 134.14,131.46
GND on BOTTOM (solid shape): 163.22,74.12 163.22,72.34 162.33,72.34 162.27,72.4 162.27,73.54 162.14,73.67 162.14,74.05 162.33,74.24 163.09,74.24
GND on BOTTOM (solid shape): 164.62,88.17 164.62,84.57 164.41,84.36 163.63,84.36 162.99,85 162.99,88.17 163.23,88.41 164.38,88.41
GND on BOTTOM (solid shape): 243.71,126.73 243.71,125.97 243.69,125.94 239.67,125.94 239.42,126.2 239.42,126.73 239.55,126.86 241.63,126.86 242.06,127.29 243.15,127.29
GND on BOTTOM (solid shape): 58.57,77.67 58.57,70.43 58.38,70.24 57.05,70.24 56.48,70.81 56.48,76.85 57.36,77.73 58.51,77.73
GND on BOTTOM (solid shape): 158.33,127.46 157.57,127.46 157.38,127.26 157.38,126.38 157.31,126.31 156.68,126.31 156.62,126.38 156.62,127.26 156.68,127.33 156.68,129.11 158.33,129.11
GND on BOTTOM (solid shape): 170.46,78.4 170.46,74.26 170.05,73.85 168.12,73.85 167.73,74.24 167.73,78.56 167.92,78.75 170.1,78.75
GND on BOTTOM (solid shape): 201.22,51.88 201.22,50.72 200.99,50.49 197.06,50.49 197.06,51.89 197.26,52.08 201.01,52.08
GND on BOTTOM (solid shape): 280.94,75.33 280.94,73.42 280.76,73.24 280.03,73.24 279.68,73.59 279.68,74.15 279.95,74.43 279.95,75.21 280.12,75.39 280.88,75.39
GND on BOTTOM (solid shape): 16.98,99.64 14.77,99.64 14.2,100.21 14.2,101.81 14.31,101.93 15.84,101.93 16.15,102.25 16.15,102.75 16.98,102.75
GND on BOTTOM (solid shape): 67.64,117.23 67.64,116.17 67.54,116.06 65.33,116.06 65.15,115.89 63.78,115.89 63.78,116.98 64.22,117.42 67.45,117.42
GND on BOTTOM (solid shape): 165.01,108.82 165.01,106.69 165.53,106.17 165.53,105.04 165.39,104.9 163.98,104.9 163.64,105.24 163.64,106.04 163.78,106.18 163.78,108.99 163.92,109.13 164.71,109.13
GND on BOTTOM (solid shape): 53.81,79.4 53.81,73.73 53.62,73.54 51.82,73.54 51.65,73.72 51.65,79.44 51.78,79.58 53.64,79.58
GND on BOTTOM (solid shape): 116.55,122.8 116.55,119.39 116.39,119.23 115.86,119.23 115.75,119.34 115.75,119.57 115.79,119.62 115.87,119.62 115.87,119.69 115.89,119.72 115.89,122.82 115.98,122.91 116.44,122.91
GND on BOTTOM (solid shape): 22.76,56.53 21.49,56.53 21.26,56.3 21.26,55.29 21.09,55.12 20.79,55.12 20.66,55.24 20.66,56.27 20.41,56.53 20.41,57.8 20.79,58.18 22.76,58.18
GND on BOTTOM (solid shape): 69.68,56.59 70.26,56.59 70.32,56.53 70.32,55.83 70.19,55.7 65.92,55.7 65.78,55.84 65.78,56.81 65.89,56.91 69.37,56.91
GND on BOTTOM (solid shape): 27.13,78.9 27.13,78.07 26.95,77.89 22.91,77.89 22.79,78 22.8,78.03 22.82,78.15 22.8,78.27 22.79,78.3 23.44,78.95 27.08,78.95
GND on BOTTOM (solid shape): 25.37,103.96 25.37,103.55 25.46,103.47 25.91,103.47 26.03,103.34 26.03,101.85 25.89,101.71 25.06,101.71 24.94,101.83 24.94,103.97 25.02,104.05 25.28,104.05
GND on BOTTOM (solid shape): 45.17,80.02 45.55,79.64 45.55,73.92 45.17,73.54 42.82,73.54 41.68,72.4 39.01,72.4 38.76,72.65 38.76,75.45 42.06,78.75 42.06,80.02 42.7,80.66 45.17,80.66
GND on BOTTOM (solid shape): 66.45,123.39 66.45,122.06 67.08,121.42 68.41,121.42 68.41,120.6 67.78,120.6 67.59,120.79 64.35,120.79 63.91,121.23 63.02,121.23 63.02,121.87 65.11,121.87 65.37,122.12 65.37,123.39 65.49,123.52 66.32,123.52
GND on BOTTOM (solid shape): 68.12,93.4 68.12,91.42 68,91.3 59.68,91.3 59.66,91.32 59.66,93.49 59.68,93.52 64.06,93.52 64.67,94.12 67.4,94.12
GND on BOTTOM (solid shape): 167.92,65.06 167.92,64.4 166.46,62.94 166.46,61.26 166.19,61 163.47,61 162.69,61.78 162.69,63.71 162.08,64.32 162.08,66.11 164.1,68.13 164.84,68.13
GND on BOTTOM (solid shape): 23.99,74.37 27.08,74.37 27.14,74.31 27.14,73.29 26.76,72.91 26,72.91 25.87,72.78 25.87,72.27 25.68,72.08 24.41,72.08 23.73,72.76 23.07,72.76 23.02,72.81 23.02,74.27 23.24,74.5 23.87,74.5
GND on BOTTOM (solid shape): 26.66,100.75 26.66,100.54 26.41,100.28 26.41,99.79 26.04,99.42 26.04,99.34 25.92,99.22 25.92,99 25.91,99 25.91,98.54 24.18,98.54 23.77,98.94 23.77,100.42 23.8,100.44 25.45,100.44 25.55,100.54 25.55,100.77 25.65,100.87 26.55,100.87
GND on BOTTOM (solid shape): 166.01,92.97 166.01,91.86 165.38,91.22 162.71,91.22 162.46,91.48 162.46,92.06 162.56,92.16 162.86,92.16 162.97,92.06 162.97,91.78 163.12,91.63 164.46,91.63 164.9,92.06 164.9,92.97 165,93.08 165.91,93.08
GND on BOTTOM (solid shape): 170.31,65.26 171.12,65.26 172.06,66.2 172.44,66.2 173.76,64.88 173.76,64.58 173.56,64.37 173.25,64.37 172.72,64.91 172.11,64.91 171.83,64.63 170.76,64.63 170.43,64.3 170.25,64.3 168.45,66.1 168.45,66.2 168.86,66.61 168.96,66.61
GND on BOTTOM (solid shape): 15.84,77.73 15.84,75.09 16.09,74.84 16.09,74.46 17.56,74.46 17.6,74.42 17.6,73.58 17.56,73.54 16.18,73.54 16.1,73.47 16.1,73.12 16.04,73.06 13.02,73.06 12.95,73.12 12.95,74.85 13,74.9 14.27,74.9 14.63,75.26 14.63,77.54 14.88,77.8 15.77,77.8
GND on BOTTOM (solid shape): 245.39,128.79 245.64,128.53 247.72,128.53 248.03,128.23 248.03,127.85 247.91,127.73 247.91,127.08 247.78,126.95 245.71,126.95 245.2,126.44 245.2,125.8 245.13,125.74 244.88,125.74 244.82,125.8 244.82,129.42 244.88,129.49 245.39,129.49
GND on BOTTOM (solid shape): 68.92,75.45 68.92,75.39 69.37,74.94 69.37,72.65 69.18,72.46 68.67,72.46 68.49,72.29 68.49,70.52 67.58,70.52 67.58,72.2 67.59,72.21 67.59,73.1 67.4,73.29 67.4,74.75 67.78,75.13 67.78,75.64 68.73,75.64
GND on BOTTOM (solid shape): 145.17,72.09 145.17,67.52 145.14,67.5 143.7,67.5 143.66,67.5 143.63,67.5 141.63,67.5 141.62,67.51 141.62,69.49 141.25,69.86 138.52,69.86 138.01,70.37 138.01,70.58 138.12,70.7 141.48,70.7 141.62,70.84 141.62,72.09 141.65,72.11 145.15,72.11
GND on BOTTOM (solid shape): 57.94,106.69 58,106.63 58.51,106.63 58.85,106.28 59.31,106.28 59.45,106.14 59.45,105.03 59.27,104.85 58.44,104.85 58.14,104.55 58.14,103.3 58.03,103.2 57.36,103.2 57.05,102.88 55.9,102.88 55.78,103.01 55.78,110.75 57.94,110.75
GND on BOTTOM (solid shape): 157.05,84.1 157.05,83.91 157.04,83.9 155.73,83.9 155.73,82.18 157.05,82.18 157.05,80.22 156.95,80.12 155.95,80.12 155.62,80.45 153.07,80.45 152.55,80.97 150.65,80.97 150.58,81.04 150.58,81.99 150.77,82.18 152.78,82.18 153.44,81.52 155.04,81.52 155.19,81.67 155.19,84.11 157.04,84.11
GND on BOTTOM (solid shape): 42.95,117.68 44.42,117.68 44.42,116.93 43.78,116.28 43.78,115.71 43.59,115.52 43.59,113.1 42.57,112.09 40.79,112.09 40.79,112.6 41.74,112.6 42.19,113.04 42.19,114.76 41.81,115.14 40.11,115.14 39.08,114.11 37.35,114.11 37.34,114.12 36.85,114.12 36.41,114.56 36.41,117.35 36.73,117.66 39.44,117.66 39.65,117.87 42.76,117.87
GND on BOTTOM (solid shape): 142.48,130.65 142.48,128.96 142.48,128.95 141.61,128.95 141.52,128.85 141.52,127.88 141.44,127.8 141.33,127.8 141.25,127.88 141.25,128.67 141.19,128.73 141.06,128.73 141.01,128.68 141.01,127.88 140.93,127.8 140.82,127.8 140.75,127.87 140.75,128.94 140.77,128.96 140.77,130.64 140.78,130.66 142.48,130.66
GND on BOTTOM (solid shape): 161.12,131.46 161.16,131.46 161.35,131.27 161.55,131.09 161.57,131.07 161.86,130.86 162.17,130.68 162.28,130.62 162.39,130.5 162.39,129.49 162.2,129.3 161.44,129.3 161.38,129.36 161.38,129.55 161.12,129.8 159.92,129.8 159.66,130.06 159.66,131.46 160.23,131.46 160.43,131.65 160.93,131.65
GND on BOTTOM (solid shape): 145.23,133.11 145.78,131.75 146.71,130.6 146.71,130.31 146.65,130.25 146.33,130.25 146.2,130.38 146.2,130.57 145.95,130.82 145.5,130.82 145.5,131.01 145.25,131.27 144.17,131.27 143.72,131.71 143.72,133.11
GND on BOTTOM (solid shape): 28.64,107.63 28.64,105.51 28.72,105.43 28.79,105.43 28.81,105.41 29.11,105.41 29.25,105.27 29.25,105.05 29.16,104.96 28.94,104.96 28.94,104.96 28.81,104.96 28.66,104.81 28.66,104.45 28.51,104.31 28.29,104.31 28.15,104.45 28.15,104.91 28.07,104.99 28.07,105.54 27.91,105.71 27.54,105.71 27.39,105.85 27.39,106.49 27.69,106.78 27.69,107.64 27.79,107.75 28.52,107.75
GND on BOTTOM (solid shape): 57.85,59.17 57.85,58.52 58.04,58.33 58.98,58.33 59.1,58.2 59.1,57.69 59.03,57.62 58.57,57.62 58.32,57.36 58.32,56.68 58.55,56.45 58.55,55.71 58.72,55.54 59.05,55.54 59.08,55.51 59.08,55.05 59.03,55 57.61,55 57.35,55.26 55.6,55.26 55.42,55.08 55.42,54.47 55.32,54.37 54.63,54.37 54.53,54.47 54.53,57.8 54.33,58 54.02,58 54.02,58.61 54.05,58.63 54.34,58.63 54.44,58.62 54.54,58.63 55.03,58.63 55.12,58.72 55.12,59.05 55.24,59.18 55.88,59.18 55.97,59.09 55.97,58.55 56.12,58.39 56.92,58.39 57.1,58.57 57.1,59.19 57.21,59.31 57.71,59.31
GND on BOTTOM (solid shape): 6.88,102.82 7.77,102.82 9.01,101.58 9.01,100.74 10.3,99.45 10.3,96.03 10.08,95.81 0.75,95.81 0.61,95.95 0.61,102.18 0.69,102.38 0.9,102.47 3.97,102.47 3.99,102.44 4.77,101.98 5.36,102.67 5.36,102.88 6.82,102.88
GND on BOTTOM (solid shape): 151.76,76.4 151.76,76.17 152.36,75.58 153.31,75.58 153.69,75.95 155.22,75.95 155.6,75.58 156.54,75.58 157.12,76.16 157.38,76.16 157.48,76.06 157.48,75.47 157.28,75.27 156.74,75.27 156.69,75.32 155.54,75.32 155.41,75.19 155.41,74.62 155.28,74.5 153.62,74.5 153.5,74.61 153.5,74.69 153.33,74.86 152.41,74.86 152.09,74.55 152.09,73.85 152.35,73.59 152.35,69.96 152.12,69.73 150.98,69.73 150.98,76.34 151.15,76.52 151.65,76.52
GND on BOTTOM (solid shape): 128.42,122.5 128.42,121.74 128.34,121.66 127.47,121.66 127.26,121.45 127.26,119.05 127.18,118.96 126.53,118.96 126.45,119.01 126.44,119.11 126.14,119.65 125.83,119.11 125.83,119.01 125.74,118.96 124.99,118.96 123.47,120.48 123.47,122.55 128.36,122.55
GND on BOTTOM (solid shape): 47.5,129.8 43.59,129.8 43.59,129.81 40.89,132.11 42.72,135.15 44.33,135.15 44.44,135.16 44.54,135.19 44.65,135.24 44.74,135.3 47.5,135.3
GND on BOTTOM (solid shape): 271.6,54.65 274.07,53.62 275.1,51.15 275.1,47.75 273.43,47.75 273.04,48.15 266.11,48.15 266.1,51.15 267.13,53.62 269.6,54.65
GND on BOTTOM (solid shape): 299.7,91.39 299.91,91.31 299.99,91.1 299.99,89.25 299.91,89.04 299.7,88.96 297.31,88.96 297.31,86.2 297.22,85.99 297.02,85.91 288.08,85.91 288.06,85.94 287.28,86.4 286.69,85.7 286.69,84.66 283.23,84.66 282.92,84.97 282.92,88.09 283.42,88.59 288.17,88.59 289.4,89.82 289.4,91.34 289.46,91.39
GND on BOTTOM (solid shape): 12.1,74.99 12.1,72.71 14.69,70.11 16.39,70.11 17.35,69.16 17.35,68.55 16.94,68.15 13.5,68.15 13.5,69.25 12.9,69.95 12.13,69.45 3.19,69.45 2.98,69.54 2.89,69.75 2.89,71.4 2.98,71.61 3.19,71.7 4.3,71.7 4.66,71.84 4.8,72.2 4.8,74.55 6.78,76.53 10.55,76.53
GND on BOTTOM (solid shape): outline of 81 points within 177.19,51.26 187.96,56.35
GND on BOTTOM (solid shape): 33.29,51.03 35.76,52.05 38.24,51.03 40.61,48.65 38.17,48.65 38.06,48.63 37.96,48.56 37.74,48.34 34.64,45.26 34.6,45.21 34.56,45.16 34.19,44.79 34.12,44.69 34.1,44.58 34.1,42.44 31.87,44.66 30.85,47.14 31.87,49.61
GND on BOTTOM (solid shape): outline of 82 points within 46.23,88.56 52.96,97.5
GND on BOTTOM (solid shape): 146.1,51.07 150.14,55.1 154.1,51 154.1,50.32 153.95,49.77 153.9,49.2 153.9,48.95 153.87,48.88 153.8,48.85 146.1,48.85
GND on BOTTOM (solid shape): 125.05,99.76 125.13,99.74 125.22,99.76 125.23,99.76 125.54,99.76 125.67,99.63 125.67,99.16 125.65,99.15 125.56,99.04 125.53,98.9 125.51,98.83 125.45,98.79 125.23,98.63 125.21,98.35 125.22,98.32 125.15,98.25 125.13,98.25 124.93,98.14 124.89,97.92 124.9,97.89 124.72,97.71 124.53,97.9 124.53,97.91 124.45,98.01 124.33,98.07 124.27,98.12 124.26,98.2 124.21,98.49 123.95,98.62 123.93,98.62 123.89,98.66 123.89,98.69 123.9,98.73 123.95,98.75 124.19,98.83 124.31,99.06 124.31,99.08 124.52,99.29 124.52,99.38 124.52,99.39 124.54,99.5 124.51,99.61 124.52,99.71 124.6,99.76 125.04,99.76
GND on BOTTOM (solid shape): 286.69,72.1 287.28,71.4 288.06,71.86 288.08,71.89 297.02,71.89 297.22,71.81 297.31,71.6 297.31,69.95 297.22,69.74 297.02,69.66 293.9,69.66 293.54,69.51 293.39,69.15 293.39,66.75 293.54,66.39 293.9,66.24 300.2,66.24 300.41,66.16 300.49,65.95 300.49,50.63 300.41,50.42 300.2,50.34 299.5,50.34 299,50.13 298.79,49.63 298.79,48.03 299,47.53 299.5,47.32 300.2,47.32 300.41,47.24 300.49,47.03 300.49,46.41 295.9,46.41 295.86,46.4 295.43,46.4 295.12,46.71 295.12,50.29 296,51.17 298.94,51.17 299.3,51.52 299.3,62.49 297.39,64.4 294.22,64.4 292.89,63.07 285.84,63.07 285.52,63.38 285.52,64.84 282.92,67.45 282.92,72.78 283.3,73.16 286.69,73.16
GND on BOTTOM (solid shape): outline of 265 points within 1.8,35.31 17.3,56.86
GND on BOTTOM (solid shape): outline of 114 points within 119.55,97.09 124.41,99.76
GND on BOTTOM (solid shape): outline of 691 points within 30.32,0.21 299.29,53.99
GND on BOTTOM (solid shape): outline of 1181 points within 0.61,71.84 299.99,136.99
GND on BOTTOM (solid shape): outline of 9782 points within 75.08,49.86 141.69,64.91
GND on GND1 (solid shape): 222.11,80.05 222.18,75.51 217.67,76.02 216.5,77.44 217.13,77.95 217.41,77.96 217.66,77.82 218.88,76.54 221.36,76.48 221.42,78.96 220.19,80.24 220.06,80.49 220.09,80.78 220.65,81.41 220.72,81.51
GND on IN1 (solid shape): 7.64,102.06 7.76,102.06 10.32,99.49 10.32,95.91 10.23,95.82 0.71,95.82 0.61,95.92 0.61,102.18 0.69,102.38 0.9,102.47 3.97,102.47 3.99,102.44 4.77,101.98 5.36,102.67 5.36,102.88 6.82,102.88
GND on IN1 (solid shape): 299.7,91.39 299.91,91.31 299.99,91.1 299.99,89.25 299.91,89.04 299.7,88.96 297.31,88.96 297.31,86.2 297.22,85.99 297.02,85.91 288.08,85.91 288.06,85.94 287.28,86.4 286.69,85.7 286.69,84.66 283.23,84.66 282.92,84.97 282.92,88.09 283.42,88.59 288.95,88.59 289.46,89.1 289.46,91.39
GND on IN1 (solid shape): 12.1,74.99 12.1,72.71 14.69,70.11 16.39,70.11 17.35,69.16 17.35,68.55 16.94,68.15 13.5,68.15 13.5,69.25 12.9,69.95 12.13,69.45 3.19,69.45 2.98,69.54 2.89,69.75 2.89,71.4 2.98,71.61 3.19,71.7 4.3,71.7 4.66,71.84 4.8,72.2 4.8,74.55 6.78,76.53 10.55,76.53
GND on IN1 (solid shape): 286.69,72.1 287.28,71.4 288.06,71.86 288.08,71.89 297.02,71.89 297.22,71.81 297.31,71.6 297.31,69.95 297.22,69.74 297.02,69.66 293.9,69.66 293.54,69.51 293.39,69.15 293.39,66.75 293.54,66.39 293.9,66.24 300.2,66.24 300.41,66.16 300.49,65.95 300.49,50.63 300.41,50.42 300.2,50.34 299.5,50.34 299,50.13 298.79,49.63 298.79,48.03 299,47.53 299.5,47.32 300.2,47.32 300.41,47.24 300.49,47.03 300.49,46.41 295.9,46.41 295.79,46.39 295.69,46.36 295.17,46.87 295.17,50.18 295.49,50.49 298.22,50.49 298.86,51.13 298.86,60.59 298.41,61.03 298.41,61.42 298.6,61.61 298.6,63.07 297.27,64.4 294.22,64.4 294.16,64.34 288.38,64.34 287.11,63.07 285.84,63.07 285.58,63.32 285.58,63.83 285.84,64.08 285.84,65.67 282.92,68.59 282.92,72.78 283.3,73.16 286.69,73.16
GND on IN1 (solid shape): outline of 258 points within 1.81,35.31 17.4,56.84
GND on IN1 (solid shape): outline of 685 points within 7.2,100.95 24.92,111.59
GND on IN1 (solid shape): outline of 1132 points within 30.25,0.21 299.29,53.58
GND on IN1 (solid shape): outline of 221 points within 0.61,71.84 299.99,136.99
GND on IN2 (solid shape): 7.71,101.99 7.71,101.93 10.32,99.31 10.32,96.05 10.1,95.82 0.72,95.82 0.61,95.93 0.61,102.18 0.69,102.38 0.9,102.47 3.97,102.47 3.99,102.44 4.77,101.98 5.36,102.67 5.36,102.88 6.82,102.88
GND on IN2 (solid shape): 299.7,91.39 299.91,91.31 299.99,91.1 299.99,89.25 299.91,89.04 299.7,88.96 297.31,88.96 297.31,86.2 297.22,85.99 297.02,85.91 288.08,85.91 288.06,85.94 287.28,86.4 286.69,85.7 286.69,84.66 283.23,84.66 282.92,84.97 282.92,88.09 283.42,88.59 288.95,88.59 289.46,89.1 289.46,91.39
GND on IN2 (solid shape): 12.1,74.99 12.1,72.71 14.69,70.11 16.39,70.11 17.35,69.16 17.35,68.55 16.94,68.15 13.5,68.15 13.5,69.25 12.9,69.95 12.13,69.45 3.19,69.45 2.98,69.54 2.89,69.75 2.89,71.4 2.98,71.61 3.19,71.7 4.3,71.7 4.66,71.84 4.8,72.2 4.8,74.55 6.78,76.53 10.55,76.53
GND on IN2 (solid shape): outline of 413 points within 282.92,46.36 300.49,73.16
GND on IN2 (solid shape): outline of 1170 points within 1.8,0.21 299.29,56.86
GND on IN2 (solid shape): outline of 220 points within 0.61,71.84 299.99,136.99
GND on IN2 (solid shape): outline of 11037 points within 75.46,53.53 143.22,99.01
GND on IN3 (solid shape): 7.71,101.99 7.71,101.93 10.32,99.31 10.32,96.03 10.11,95.82 0.75,95.82 0.61,95.96 0.61,102.18 0.69,102.38 0.9,102.47 3.97,102.47 3.99,102.44 4.77,101.98 5.36,102.67 5.36,102.88 6.82,102.88
GND on IN3 (solid shape): 299.7,91.39 299.91,91.31 299.99,91.1 299.99,89.25 299.91,89.04 299.7,88.96 297.31,88.96 297.31,86.2 297.22,85.99 297.02,85.91 288.08,85.91 288.06,85.94 287.28,86.4 286.69,85.7 286.69,84.66 283.23,84.66 282.92,84.97 282.92,88.09 283.42,88.59 288.95,88.59 289.46,89.1 289.46,91.39
GND on IN3 (solid shape): 12.1,74.99 12.1,72.71 14.69,70.11 16.39,70.11 17.35,69.16 17.35,68.55 16.94,68.15 13.5,68.15 13.5,69.25 12.9,69.95 12.13,69.45 3.19,69.45 2.98,69.54 2.89,69.75 2.89,71.4 2.98,71.61 3.19,71.7 4.3,71.7 4.66,71.84 4.8,72.2 4.8,74.55 6.78,76.53 10.55,76.53
GND on IN3 (solid shape): outline of 261 points within 1.81,35.31 17.36,56.79
GND on IN3 (solid shape): outline of 376 points within 282.92,46.36 300.49,73.16
GND on IN3 (solid shape): outline of 803 points within 28.98,0.21 299.29,53.57
GND on IN3 (solid shape): outline of 992 points within 5.23,101.53 23.07,111.59
GND on IN3 (solid shape): outline of 227 points within 0.61,71.84 299.99,136.99
GND on GND2 (solid shape): 222.29,79.89 222.08,75.42 217.65,76.05 216.37,77.38 217.13,77.95 217.41,77.96 217.66,77.82 218.88,76.54 221.36,76.48 221.42,78.96 220.19,80.24 220.06,80.49 220.09,80.78 220.6,81.38 220.75,81.54
GND on TOP: 238.4,97.29 238.86,97.29 239.41,96.74 239.84,96.74 239.95,96.63 239.95,95.9 239.55,95.49 239.55,94.44 239.17,94.05 238.47,94.05 238.4,94.12
GND on GND1: outline of 347 points within 0.21,0.21 300.49,136.99 ; 2 cut-outs
