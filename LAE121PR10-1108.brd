# Allegro board LAE121PR10-1108.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RR8  -  [R0402_0OHM]  280.05 62.11 0 top
RR9  -  [R0402_0OHM]  276.82 61.17 270 top
RR10  -  [R0402_0OHM]  277.71 61.17 270 top
RR19  -  [R_0402]  272.85 68.62 90 top
RT1  -  [R_0402]  32.21 89.67 0 bottom
RT2  -  [R_0402]  37.95 89.23 180 top
RT3  -  [R_0402]  37.95 88.34 180 top
RT4  -  [R_0402]  37.95 87.45 180 top
RT5  -  [R_0402]  33.67 97.48 0 bottom
RT6  -  [R_0402]  32.97 95.71 0 bottom
RT7  -  [R_0402]  32.97 96.59 0 bottom
RT8  -  [R_0402]  33.67 98.37 0 bottom
RT9  -  [R0402_0OHM]  37.25 90.12 180 top
RT10  -  [R_0402]  37.04 85.41 90 top
RT11  -  [R_0402]  25.11 95.21 270 bottom
RT12  -  [R_0402]  34.44 92.8 270 top
RT13  -  [R_0402]  35.33 92.8 270 top
RT14  -  [R_0402]  39.01 94.68 90 top
RT15  -  [R_0402]  39.01 94.68 90 bottom
RT16  -  [R_0402]  27.71 92.73 270 bottom
RT17  -  [R_0402]  26.06 92.73 270 top
RT18  -  [R_0402]  30.57 90.93 90 top
RT19  -  [R_0402]  31.77 90.93 90 top
RT20  -  [R_0402]  27.98 92.73 270 top
RT21  -  [R_0402]  21.56 98.69 180 top
RT22  -  [R_0402]  21.56 99.58 180 top
RT23  -  [R_0402]  28.85 96.73 270 bottom
RT24  -  [R_0402]  38.89 92.8 270 top
RT25  -  [R_0402]  25.93 92.73 270 bottom
RT26  -  [R_0402]  25.12 96.98 180 bottom
RT27  -  [R_0402]  25.04 92.73 270 bottom
RT28  -  [R_0402]  32.66 92.8 270 top
RT29  -  [R_0402]  34.57 99.25 90 bottom
RT30  -  [R_0402]  38 92.8 270 top
RT31  -  [R_0402]  19.39 98.68 90 top
RT32  -  [R_0402]  21.56 100.47 180 top
RT33  -  [R_0402]  28.97 92.73 270 top
RT34  -  [R_0402]  32.56 106.06 90 bottom
RT35  -  [R_0402]  35.46 99.25 90 bottom
RT36  -  [R_0402]  25.17 92.73 270 top
RT37  -  [R_0402]  36.33 97.17 0 top
RT38  -  [R_0402]  33.68 104.33 90 bottom
RT39  -  [R_0402]  27.51 99.97 0 bottom
RT40  -  [R0402_0OHM]  22.68 108.53 0 top
RT41  -  [R_0402]  26.74 106.14 0 bottom
RT42  -  [R_0402]  25.42 105.92 90 bottom
RT48  -  [R_0603]  24.34 88.85 270 top
RT49  -  [R_0603]  23.14 88.59 90 top
RT50  -  [R_0402]  30.14 70.5 180 top
RT51  -  [R_0402]  27.06 69.54 0 top
RT52  -  [R_0402]  27.06 70.5 0 top
RT53  -  [R_0402]  27.06 72.4 0 top
RT54  -  [R0402_0OHM]  30.14 71.51 180 top
RT55  -  [R0402_0OHM]  30.14 72.4 180 top
RT56  -  [R0402_0OHM]  27.06 71.45 0 top
RT57  -  [R0402_0OHM]  27.06 68.59 0 top
RT58  -  [R0402_0OHM]  39.91 82.88 180 bottom
RT59  -  [R0402_0OHM]  39 79.39 0 bottom
RT60  -  [R0402_0OHM]  36.93 80.66 180 top
RT63  -  [R0402_0OHM]  32.41 86.1 90 top
RT64  -  [R_0402]  36.02 78.75 0 top
RT65  -  [R_0402]  36.02 77.86 0 top
RT66  -  [R_0402]  38.51 82.68 90 top
RT67  -  [R_0402]  37.62 82.68 90 top
RT68  -  [R_0402]  36.02 79.69 0 top
RT69  -  [R_0402]  35.71 85.41 90 top
RT70  -  [R0402_0OHM]  34.25 87.02 270 top
RT71  -  [R_0402]  33.74 78.48 90 bottom
RT72  -  [R0402_0OHM]  29.93 75.44 90 top
RT73  -  [R0402_0OHM]  30.87 78.75 0 bottom
RT74  -  [R_0402]  31.79 77.8 180 bottom
RT75  -  [R_0402]  29.5 74.18 180 top
RT76  -  [R_0402]  28.42 82.59 180 bottom
RT81  -  [R_0402]  32.22 86.8 90 bottom
RT82  -  [R_0402]  31.33 86.8 90 bottom
RT83  -  [R0402_0OHM]  31.32 85.93 0 bottom
RT84  -  [R_0402]  28.66 85.98 90 bottom
RT85  -  [R_0402]  28.87 84.4 180 bottom
RT86  -  [R_0402]  31.9 76.35 270 top
RT87  -  [R0402_0OHM]  24.9 81.48 0 top
RT88  -  [R0402_0OHM]  24.9 82.37 0 top
RT89  -  [R_0402]  24.22 81.15 90 bottom
RT90  -  [R_0402]  23.33 81.15 90 bottom
RT92  -  [R0402_0OHM]  25.47 84.66 0 top
RT93  -  [R0402_0OHM]  25.47 85.55 0 top
RT95  -  [R_0402]  28.1 87.26 180 top
RT96  -  [R_0402]  28.97 87.26 0 top
RT97  -  [R_0402]  31.66 73.29 180 top
RT98  -  [R_0402]  29.5 73.29 180 top
RT99  -  [R0402_0OHM]  30.75 74.18 0 top
RT100  -  [R_0402]  30.44 85.98 90 bottom
RT101  -  [R_0402]  32.23 81.35 180 bottom
RT103  -  [R_0402]  27.65 76.1 270 top
RT104  -  [R0402_0OHM]  26.83 78.56 180 top
RT105  -  [R0402_0OHM]  26.83 77.54 180 top
RT106  -  [R_0402]  29.55 85.98 90 bottom
RT107  -  [R_0402]  33.62 81.91 90 bottom
RT108  -  [R0402_0OHM]  26.44 79.58 180 top
RT109  -  [R0402_0OHM]  26.44 80.47 180 top
RT110  -  [R_0402]  30.89 76.35 270 top
RT111  -  [R_0402]  21.09 68.15 0 top
RT120  -  [R0402_0OHM]  15.59 107.14 180 top
RT121  -  [R0402_0OHM]  15.59 106.25 180 top
RT122  -  [R0402_0OHM]  14.68 107.14 0 bottom
RT123  -  [R0402_0OHM]  14.68 106.25 0 bottom
RT124  -  [R_0402]  33.55 92.8 270 top
RT125  -  [R_0402]  36.22 92.8 270 top
RT126  -  [R_0402]  38.12 94.68 90 top
RT127  -  [R_0402]  38.12 94.68 90 bottom
RT128  -  [R_0402]  36.85 100.15 270 bottom
RT129  -  [R_0402]  29.74 96.73 270 bottom
RT336  -  [R_0402]  38.17 99.49 0 bottom
RT337  -  [R_0402]  30.63 96.73 270 bottom
RT338  -  [R_0402]  37.11 92.8 270 top
RT339  -  [R_0402]  32.23 80.47 180 bottom
RT341  -  [R0402_0OHM]  39.03 93.8 180 top
RT342  -  [R0402_0OHM]  39.03 93.8 180 bottom
RT371  -  [R_0402]  36.22 92.8 270 bottom
RT372  -  [R_0402]  26.82 92.73 270 bottom
RT377  -  [R_0402]  29.3 81.34 90 bottom
RT391  -  [R_0402]  134.06 122.92 270 bottom
RT392  -  [R0402_0OHM]  27 91.82 90 top
RT393  -  [R_0402]  21.09 69.06 0 top
RV1  -  [R_0402]  71.47 126.19 180 top
RV2  -  [R_0402]  72.24 122.31 180 top
RV3  -  [R_0402]  70.39 122.31 180 top
RV4  -  [R_0402]  43.08 123.72 270 top
RV5  -  [R_0402]  42.19 124.59 90 top
RV6  -  [R_0402]  50.32 121.03 90 top
RV7  -  [R_0402]  64.21 132.15 0 top
RV8  -  [R_0402]  61.49 133.31 270 top
RV10  -  [R_0402]  18.77 80.53 180 top
RV11  -  [R_0402]  18.77 81.42 180 top
RV12  -  [R_0402]  18.77 82.37 180 top
RV13  -  [R_0402]  18.77 83.26 180 top
RV14  -  [R_0402]  18.77 86.05 180 top
RV15  -  [R_0402]  18.77 86.94 180 top
RV16  -  [R_0402]  18.77 84.21 180 top
RV17  -  [R_0402]  18.77 85.1 180 top
RV18  -  [R_0402]  18.49 77.04 0 top
RV19  -  [R_0402]  20.33 91.22 0 bottom
RV20  -  [R_0402]  24.98 90.13 270 bottom
RV21  -  [R_0402]  24.03 88.54 270 bottom
RV22  -  [R_0402]  16.79 89.85 90 top
RV23  -  [R_0402]  16.79 88.99 270 top
RV26  -  [R_0402]  16.72 81.43 270 bottom
RV29  -  [R_0402]  16.72 83.27 270 bottom
RV32  -  [R_0402]  16.72 86.96 270 bottom
RV35  -  [R_0402]  16.72 85.11 270 bottom
RV70  -  [R_0402]  106.2 131.25 90 top
RV71  -  [R_0402]  107.09 129.31 270 top
RV73  -  [R_0402]  110.5 132.22 0 top
RV74  -  [R_0402]  113.26 132.22 180 top
RV76  -  [R_0402]  107.09 131.25 90 top
RV77  -  [R_0402]  106.2 129.31 270 top
RV79  -  [R_0402]  119.34 131.82 90 bottom
RV80  -  [R_0402]  120.23 131.82 90 bottom
RV81  -  [R_0402]  122.01 131.82 90 bottom
RV82  -  [R_0402]  121.12 131.82 90 bottom
RV83  -  [R_0402]  122.9 131.82 90 bottom
RV84  -  [R_0402]  123.79 131.82 90 bottom
RV85  -  [R_0402]  119.33 128.22 0 bottom
RV87  -  [R_0402]  114.57 126.88 0 top
RV88  -  [R_0402]  114.57 127.77 0 top
RV89  -  [R_0402]  108.36 125.69 270 bottom
RV90  -  [R_0402]  119.33 130.19 0 bottom
RV91  -  [R_0402]  119.33 129.3 0 bottom
RV93  -  [R_0402]  119.33 126.44 0 bottom
RV94  -  [R_0402]  119.33 125.55 0 bottom
RV95  -  [R_0402]  119.33 127.33 0 bottom
RV97  -  [R_0402]  107.28 126.33 270 bottom
RZ8  -  [R_0402]  233.32 55.21 270 top
RZ9  -  [R_0402]  233.32 52.51 90 top
RZ10  -  [R_0402]  222.53 58.57 270 top
RZ18  -  [R_0402]  209.5 58.49 0 top
RZ19  -  [R_0402]  212.19 58.49 180 top
RZ20  -  [R_0402]  214.07 54.94 0 top
RZ21  -  [R_0402]  216.76 54.94 180 top
RZ22  -  [R_0402]  210.46 57.11 270 top
RZ23  -  [R_0402]  211.34 57.48 0 top
RZ25  -  [R_0402]  285.66 12.58 180 bottom
RZ26  -  [R0402_0OHM]  214.97 55.81 90 top
RZ28  -  [R_0402]  287.55 10.69 270 bottom
RZ29  -  [R0402_0OHM]  215.86 55.81 90 top
RZ32  -  [R_0402]  269.71 83.5 90 top
RZ38  -  [R_0402]  251.17 104.01 90 top
RZ40  -  [R_0402]  280.69 86.93 90 top
RZ43  -  [R_0402]  239.5 111.83 180 top
RZ56  -  [R0402_0OHM]  238.42 67.89 180 top
RZ58  -  [R_0402]  161.52 105.17 180 top
RZ59  -  [R_0402]  160.17 101.09 90 top
RZ60  -  [R_0402]  159.08 104.68 90 bottom
RZ61  -  [R0402_0OHM]  158.08 104.7 90 bottom
RZ62  -  [R_0402]  155.13 109.37 180 bottom
RZ63  -  [R_0402]  159.99 104.68 90 bottom
RZ64  -  [R0402_0OHM]  160.11 60.86 270 top
RZ65  -  [R_0402]  161 60.86 270 top
RZ69  -  [R_0402]  161.94 104.68 90 bottom
RZ70  -  [R0402_0OHM]  252.63 107.19 90 top
RZ71  -  [R_0402]  251.74 107.19 90 top
RZ76  -  [R_0402]  241.01 102.2 180 top
RZ77  -  [R_0402]  241.01 101.31 180 top
RZ78  -  [R_0402]  237.5 67 0 top
RZ79  -  [R_0402]  237.5 66.11 0 top
RZ80  -  [R_0402]  237.5 65.23 0 top
RZ81  -  [R_0402]  237.5 64.34 0 top
RZ85  -  [R0402_0OHM]  223.53 52.84 0 top
RZ87  -  [R0402_0OHM]  221.64 58.57 270 top
RZ89  -  [R0402_0OHM]  160.58 115.73 0 bottom
RZ111  -  [R_0402]  159.71 114.25 90 bottom
RZ112  -  [R_0402]  154.21 110.25 0 bottom
RZ113  -  [R_0402]  157.17 105.61 270 bottom
RZ114  -  [R_0402]  223.79 58.57 270 top
RZ116  -  [R_0402]  214.08 55.81 90 top
RZ117  -  [R_0402]  216.75 55.81 90 top
RZ119  -  [R_0402]  134.64 68.39 90 top
RZ120  -  [R0402_0OHM]  140.18 66.3 180 top
RZ128  -  [R_0201]  233.51 84.59 270 bottom
RZ129  -  [R_0201]  234.17 84.59 270 bottom
RZ130  -  [R_0201]  234.83 84.59 270 bottom
RZ131  -  [R_0402]  238.7 98.96 270 top
RZ132  -  [R_0402]  237.78 98.96 270 top
RZ151  -  [R_0603]  121.44 121.61 0 top
RZ320  -  [R_0402]  123.8 128.47 180 bottom
RZ326  -  [R_0402]  231.05 106.06 180 top
RZ334  -  [R_0402]  277.65 58.51 270 bottom
RZ335  -  [R_0402]  277.65 55.76 90 bottom
RZ345  -  [R0402_0OHM]  203.99 52.28 270 top
RZ346  -  [R0402_0OHM]  213.19 55.81 90 top
RZ347  -  [R0402_0OHM]  216.76 57.61 180 top
RZ361  -  [R_0402]  241.96 93 180 top
RZ362  -  [R_0402]  154.21 111.12 0 bottom
RZ363  -  [R0402_0OHM]  158.84 115.16 270 bottom
SW1  -  [SW_SS3-CMFTQR9_3P]  228.24 82.83 65 bottom
SW3  -  [SW_SKRBAAE010_4P]  295.67 126.44 180 top
T1  -  [TPC12]  105.58 109.06 0 top
T2  -  [TPC12]  105.1 110.35 0 top
T3  -  [TPC12]  97.88 84.62 0 top
T4  -  [TPC12]  97.94 85.79 180 bottom
T9  -  [TPC12]  84.38 121.22 180 bottom
T10  -  [TPC12]  101.65 115.53 180 bottom
T11  -  [TPC12]  100.61 116.28 180 bottom
T12  -  [TPC12]  84.73 86.5 180 bottom
T13  -  [TPC12]  87.27 86.5 180 bottom
T14  -  [TPC12]  125.18 98.88 0 top
T15  -  [TPC12]  126.69 98.49 0 top
T16  -  [TPC12]  86 86.5 180 bottom
T17  -  [TPC12]  84.73 87.77 180 bottom
T50  -  [TPC12]  118.45 51.45 180 bottom
T51  -  [TPC12]  119.85 60.15 0 top
T88  -  [TPC12]  242.42 132.13 0 top
T89  -  [TPC12]  243.47 130.81 0 top
T113  -  [TPC12]  87.27 87.77 180 bottom
T114  -  [TPC12]  86 87.77 180 bottom
T115  -  [TPC12]  125.08 95.43 0 top
T120  -  [TPC12]  125.78 106.26 0 top
T122  -  [TPC12]  114.17 108.47 0 top
T123  -  [TPC12]  114.11 97.96 0 top
T126  -  [TPC12]  136.88 89.75 180 bottom
T127  -  [TPC12]  135.63 90.16 180 bottom
T130  -  [TPC12]  135.48 88.66 180 bottom
T132  -  [TPC12]  93.6 91.98 0 top
T219  -  [TPC12]  28.68 87.84 180 bottom
T220  -  [TPC12]  27.02 84.39 270 bottom
T225  -  [TPC12]  230.94 95.26 0 top
T226  -  [TPC12]  94.46 90.97 0 top
T258  -  [TPC12]  134.64 87.58 180 bottom
T262  -  [TPC12]  249.96 96.56 0 top
T264  -  [TPC12]  250.52 95.39 0 top
T267  -  [TPC12]  271.8 92.21 0 top
T268  -  [TPC12]  136.07 87.49 180 bottom
T269  -  [TPC12]  135.28 120.09 180 bottom
T283  -  [TPC12]  163.16 109.92 180 bottom
TL1  -  [MHPC_NS692417_24P]  258.72 128.94 0 bottom
UA1  -  [ALC3246-CG_MQFN48_6X6]  259.53 63.39 270 top
UC1  -  [SKL-U_BGA_1356P-T]  132.41 113.31 0 bottom
UC5  -  [W25Q128FVSIQ_SO8]  160.68 95.32 270 bottom
UC6  -  [W25Q128FVSIQ_SO8]  160.68 101.23 270 bottom
UC7  -  [TC7SH08FU_SSOP5]  156.68 119.79 270 bottom
UC8  -  [74CBTLV3126BQ_DHVQFN14_2P5X3-S]  82.78 122.3 180 bottom
UC12  -  [74AHC1G09GW_TSSOP5]  151.29 115.98 270 bottom
UD1  -  [74AUP1G07GW_TSSOP5]  72.36 84.16 270 bottom
UE1  -  [MEC5105_WFBGA_169P]  246.68 83.86 90 top
UE2  -  [IT8010FN-BX-R_QFN20_4X4]  267.25 90.67 90 top
UE3  -  [TC7SH08FU_SSOP5]  266.6 98.9 270 top
UE4  -  [74AUP1G07GW_TSSOP5]  269.88 96.78 0 top
UE5  -  [TC7SH08FU_SSOP5]  263.23 98.96 270 top
UE6  -  [74AUP1G07GW_TSSOP5]  266.65 80.73 270 top
UE7  -  [AP2112K-3P3TRG1_SOT23-5]  241.85 98.56 270 top
UE9  -  [W25Q80DVSSIG_SO8]  249.84 123.07 270 bottom
UI1  -  [SY6288D20AAC_SOT23-5]  20.02 55.52 0 bottom
UI3  -  [SLGC55544CVTR_TQFN16_3X3]  277.51 77.32 180 top
UL1  -  [WGI217LM-QPN9-A2_QFN48_6X6-S]  244.08 122.96 0 top
UL2  -  [TC7SH08FU_SSOP5]  254.97 132.74 270 bottom
UR1  -  [RTS5242-GR_QFN32_4X4-S]  273.22 66.27 0 top
UT1  -  [ALPINE-RIDGE_BGA_337P]  24.3 96.55 90 top
UT2  -  [W25Q80DVSSIG_SO8]  41.88 90.43 270 bottom
UT5  -  [TPS65982_BGA_96P]  34.02 83.47 270 top
UT6  -  [W25Q80DVSSIG_SO8]  25.04 68.59 90 bottom
UT7  -  [AP2112K-3P3TRG1_SOT23-5]  19.97 67.56 0 bottom
UT8  -  [AP2204R-5P0TRG1_SOT89-3]  16.91 75.49 270 bottom
UV2  -  [AP2330W-7_SC59-3]  19.26 90.87 180 bottom
UV7  -  [PS8338BQFN60GTR-A0_QFN60_5X9-S]  117.11 127.25 180 bottom
UV24  -  [G524B1T11U_SOT23-5]  66.8 125.27 180 top
UZ2  -  [TPS22966DPUR_SON14_2X3]  252.32 110 90 top
UZ3  -  [TPS22966DPUR_SON14_2X3]  158.59 59.14 90 top
UZ4  -  [TPS22966DPUR_SON14_2X3]  279.19 89.74 90 top
UZ5  -  [TPS22966DPUR_SON14_2X3]  245.38 65.03 270 top
UZ6  -  [TC7SH08FU_SSOP5]  203.1 59.72 270 top
UZ8  -  [AOZ1336_DFN8_2X2]  206.38 52.39 270 top
UZ10  -  [TC7SH08FU_SSOP5]  268.56 84.83 90 top
UZ12  -  [NPCT650JB2YX_QFN32_5X5]  157.33 112.52 270 bottom
UZ19  -  [TPS22961DNYR_WSON8]  123.74 128.49 180 top
UZ21  -  [TPS22961DNYR_WSON8]  128.13 128.49 180 top
UZ26  -  [TPS22961DNYR_WSON8]  135.89 66.61 0 top
UZ34  -  [TC7SH08FU_SSOP5]  140.44 69.6 180 top
UZ35  -  [TC7SH08FU_SSOP5]  124.35 130.77 270 bottom
YC1  -  [Y_X3G024000DC1H_4P]  112.84 122.04 0 bottom
YC2  -  [Y_9H03200042_2P]  134.81 80.15 180 top
YE1  -  [Y_X1A000141000200_2P]  242.02 82.2 90 top
YL1  -  [Y_7V25000034_4P]  248.9 118.13 180 top
YT1  -  [Y_7V25000034_4P]  22.1 110.05 0 top

## Library data of the parts
CA1-CA6 CA12 CA13 CA19 CA22-CA24 CA27 CA28 CA33 CA35 CA41 CA54 CA62-CA69 CA72 CC7 CC8 CC21-CC27 CC32 CC33 CC176-CC179 CC195 CC199 CC202-CC209 CC211-CC213 CC215-CC218 CC222 CC224 CC250-CC253 CC264-CC266 CC269 CC288 CC297 CC300-CC308 CC310 CC312 CC316 CC318-CC326 CC331-CC333 CD9-CD16 CD18 CD19 CD23-CD27 CD29 CD31 CE1-CE6 CE8 CE10 CE12 CE14 CE24 CE26-CE31 CE35-CE40 CE46 CE47 CE52-CE54 CE57 CE59-CE62 CE500 CE503 CI4 CI5 CI13 CI16 CI29-CI31 CI43-CI46 CL1 CL2 CL5 CL6 CL13 CL14 CL18 CL29 CL30 CN60 CN69-CN72 CR1 CR4 CR11-CR15 CR21 CR22 CR25-CR28 CT20 CT21 CT44-CT47 CT59 CT60 CT67 CT70-CT74 CT83 CT85-CT87 CT89 CT90 CT92 CT93 CT189 CV1-CV6 CV13 CV14 CV17-CV25 CV31-CV38 CV81 CV82 CV96 CV145-CV150 CV152 CV153 CV156 CV157 CZ3 CZ12-CZ15 CZ17-CZ19 CZ21 CZ23-CZ25 CZ28 CZ29 CZ33-CZ41 CZ56-CZ63 CZ69 CZ71-CZ73 CZ75 CZ80 CZ81 CZ83 CZ100 CZ102 CZ104 CZ105 CZ109 CZ110 CZ113 CZ114 CZ117 CZ118 CZ121 CZ124 CZ126 CZ127 CZ197 CZ198 PC1 PC2 PC9 PC10 PC100 PC103 PC113 PC115 PC116 PC127 PC128 PC202 PC203 PC206-PC208 PC216-PC218 PC221 PC222 PC301 PC303 PC307 PC401 PC402 PC408-PC411 PC417-PC420 PC503 PC505 PC506 PC513 PC515 PC601 PC602 PC605 PC613 PC614 PC616-PC621 PC624-PC633 PC636 PC637 PC639-PC647 PC649-PC654 PC659-PC661 PC677 PC679 PC680 PC685 PC686 PC688 PC902 PC903 PC925-PC929 PC932 PC933 PC937-PC939 PC942-PC947 PC949 PC950 PC1201 PC1203-PC1208 PC1210-PC1214 PC1216 PC1217 PC1286 = C_0402
CA7 CA8 CA10 CA45 CA47 CA55 CA57 CA60 CC9 CC10 CC28-CC30 CC214 CC223 CC270 CC281 CC313 CC314 CD28 CD32 CE11 CE13 CE15 CE18-CE23 CE25 CI3 CI7 CI17 CI19 CL3 CL7-CL11 CL15-CL17 CL19-CL21 CN61 CN62 CR2 CR3 CR6 CR7 CR17 CR19 CT1-CT19 CT25-CT43 CT48-CT54 CT61-CT64 CT80 CT81 CT88 CT95-CT102 CT123-CT130 CT168-CT177 CT201-CT204 CV12 CV39 CV40 CV83-CV95 CZ1 CZ2 CZ30 CZ31 CZ50 CZ51 CZ53 CZ54 CZ64 CZ66-CZ68 CZ82 CZ90-CZ93 CZ101 CZ103 CZ106 CZ111 CZ112 CZ115 CZ116 CZ119 CZ120 CZ122 CZ125 CZ128 PC1030-PC1056 PC1083-PC1099 PC1125 PC1126 PC1147-PC1153 PC1164 = C_0201
CA9 CA25 CA29 CA31 CA43 CA44 CA46 CA48 CA49 CA51-CA53 CA56 CA58 CA59 CA61 CC279 CC280 CC294-CC296 CD1-CD8 CD20-CD22 CE16 CE17 CE32 CI6 CI33 CI34 CL4 CL12 CN63 CN64 CR5 CR18 CR20 CT55-CT57 CT82 CT84 CT91 CT94 CV11 CV15 CV16 CV41 CZ20 CZ27 CZ32 CZ52 CZ55 PC3-PC7 PC11 PC102 PC111 PC112 PC114 PC119 PC125 PC126 PC204 PC205 PC209-PC214 PC219 PC302 PC304-PC306 PC308-PC313 PC403 PC404 PC406 PC407 PC412 PC413 PC415 PC416 PC422 PC424 PC501 PC502 PC504 PC514 PC516 PC603 PC604 PC611 PC622 PC655 PC662 PC671 PC678 PC930 PC931 PC934 PC940 PC941 PC1001-PC1029 PC1057-PC1061 PC1064-PC1082 PC1129-PC1146 PC1170-PC1181 PC1202 = C_0603
CC210 CC219-CC221 CC225 CC226 CL28 CT68 CT69 CT75-CT78 PC8 PC104-PC110 PC117 PC118 PC120-PC124 PC129 PC130 PC200 PC201 PC608 PC612 PC656-PC658 PC663-PC665 PC672 PC673 PC904-PC906 PC911 PC913-PC920 PC935 PC936 = C_0805
CD17 PC1062 PC1063 = C_D3
CI1 CI14 = C_1206
CI32 CZ26 PC909 PC910 PC951 = C_B2
CL22 = C_1808
CMOS1 = SHORTPADS-NPM: User Part Number: PART#
DA1-DA3 DA6 DA7 = L03ESDL5V0CC3-2_SOT23-3
DA8 DE1 DZ1 DZ2 DZ5-DZ7 = RB751S40T1G_SOD523-2
DI1 DI4 = L05ESDL5V0NA-4_SLP2510P8-10-9
DI2 DI5 DV4 = AZC199-02SPR7G_SOT23-3
DT1-DT3 = 1N4148WS-7-F_SOD323-2
DT4 = L30ESD24VC3-2_SOT23-3
DT5-DT20 DV7 DV8 = ESD8011MUT5G_X3DFN2-2-S
DV1-DV3 PD905 PD1801 = BAT54CW_SOT323-3
FD1-FD4 = FIDUCIAL_C40M80
H1-H4 = H_3P4
H5 H6 = H_1P0N
H7 H8 H25 H26 = H_3P2
H9 H14-H16 H18 H23 H24 H29 H33 H38 = H_2P6-G
H10 = H_3P8-G
H12 H21 H22 H27 H28 = H_3P5-G
H20 H37 = H_3P1-G
H30 = H_2P3X2P7N
H39 = H_2P3N
JAPS1 = CVILU_CF4218FH0R0-05-NH_18P-T
JDB1 = ACES_50506-00641-P01_6P
JDEG1 = HB_A531015-SCHR21_10P
JDIMM1 = LCN_DAN05-Q0406-0103_260P
JEDP1 = ACES_50398-04041-001_40P
JESPI = ACES_50506-01041-P01_10P
JFAN1 = ACES_50271-0040N-001_4P
JHDMI1 = ACON_HMRBL-A41L0F_19P-T
JHP1 = SINGA_2SJ3095-085111F_6P
JIR1 = E-T_4251K-F06N-40L_6P
JKBTP1 = CVILU_CF5020FD0RK-05-NH_20P-T
JLED1 = ACES_50209-0060N-P01_6P
JLOM1 = SANTA_130470-19_13P-T
JNGFF1 = LCN_DAN05-67306-0100_75P
JNGFF2 = BELLW_80149-3221_67P
JNGFF3 = LOTES_APCI0170-P001A_75P
JRTC1 = ACES_50271-0020N-001_2P
JSD1 = T-SOL_158-1240902600_23P-T
JSIM1 = JAE_SF51S006V4DR1000Q_8P
JSPI1 = E-T_6705K-Y20N-00L_20P
JSPK1 = ACES_50278-0040N-001_4P
JTAG1 = SHORTPADS: User Part Number: PART#
JUART1 = CVILU_CI1804M1VRA-NH_4P
JUSB1 JUSB2 = ACON_TCRA2-9U1U93_9P-T
JUSBC1 = JAE_DX07B024XJ1R1300_24P
JUSH1 = CVILU_CF5026FD0RK-05-NH_26P-T
JXDP1 = E-T_6601K-Y61N-04L_61P
LA5 LA12 LA14 = MURAT_BLM15PX600SN1D_2P
LA6-LA11 = MURAT_BLM15PX330SN1D_2P
LA13 = TAI-T_HCB2012VF-601T20_2P
LC1 LC2 = MURAT_BLM15GA750SN1D_2P
LED3 = LED_LTW-C193DC-C_2P
LI3 LI7 LV27 LZ1 = PANAS_EXC24CQ900U_4P
LI8 LI9 LI16 LI17 = INPAQ_HCM2012GA900AE_4P
LL1 = TAIYO_BRC2012T4R7MD_2P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LT2 = MURAT_LQM18NN1R0K00D_2P
LV1 = MURAT_BLM15PX221SN1D_2P
LV3 LV6 LV9 LV12 = TAIYO_MCF12102G900-T_4P
LV31-LV38 = MURAT_LQG15HN12NJ02D_2P
PBATT1 = DEREN_40-42251-01001RHF_10P-T
PC606 = C_D
PC1127 PC1128 = C_D2
PD1 PD2 = TVNST52302AB0_SOT523-3
PD3 = DB3J315E0L_SMINI3-F2-B3
PD4 = PESD5V0U2BT_SOT23-3
PD5 PD1202 = PDS5100H-13_POWERDI5-3
PD100 PD903 = RB520SM-30T2R_EMD2-2
PD901 PD904 PD1205 = SDMK0340L-7-F_SOD323-2
PH601-PH605 PR1-PR8 PR10-PR12 PR14-PR18 PR24 PR27 PR28 PR102 PR103 PR107 PR108 PR113 PR116 PR117 PR204-PR207 PR209 PR212 PR302 PR306-PR308 PR310 PR311 PR403 PR404 PR407 PR408 PR410-PR422 PR424 PR427 PR428 PR501 PR505 PR506 PR514-PR517 PR601 PR604 PR605 PR608 PR610-PR613 PR617 PR618 PR621-PR623 PR626 PR628-PR633 PR635 PR636 PR638-PR652 PR656 PR657 PR662 PR678 PR680 PR909 PR910 PR915 PR918 PR919 PR925 PR927 PR930-PR934 PR937 PR938 PR940 PR944 PR945 PR948 PR950 PR953 PR1201-PR1203 PR1205-PR1210 PR1212-PR1214 PR1217 PR1219 PR1222 PR1224 PR1226-PR1237 PR1239 PR1240 PR1246-PR1249 PR1251-PR1255 PR1258-PR1261 RA5-RA9 RA12-RA14 RA17 RA18 RA44 RA45 RA50-RA53 RA57-RA61 RC1-RC7 RC10-RC17 RC19-RC23 RC25 RC27-RC32 RC39 RC42-RC48 RC50-RC52 RC54 RC56 RC57 RC59 RC60 RC65 RC67-RC69 RC71-RC75 RC77-RC84 RC86-RC96 RC109 RC110 RC112-RC115 RC120-RC124 RC126 RC128-RC141 RC152 RC153 RC157 RC161 RC163 RC165-RC168 RC175-RC178 RC183 RC184 RC186 RC187 RC189 RC190 RC211 RC215 RC217-RC220 RC222-RC225 RC227 RC234 RC237 RC239-RC241 RC243 RC267 RC268 RC272 RC278 RC279 RC282 RC283 RC287 RC288 RC291 RC292 RC297 RC298 RC311 RC313 RC316-RC319 RC323 RC324 RC330 RC331 RC338 RC344-RC349 RC362 RC363 RC366-RC369 RC371 RC372 RC387 RC400-RC403 RC405 RC407-RC414 RD4 RD6 RD8 RD11 RD14-RD19 RE5 RE6 RE8 RE10-RE18 RE20 RE21 RE25 RE26 RE31 RE33 RE35 RE37 RE38 RE43 RE48 RE51 RE55-RE58 RE60 RE63-RE65 RE67-RE75 RE77 RE79 RE83-RE86 RE91 RE92 RE94 RE95 RE98 RE274 RE280 RE288 RE292 RE300-RE304 RE306 RE308 RE312-RE314 RE324 RE337-RE343 RE348-RE350 RE361-RE363 RE365-RE377 RE505 RE507 RE508 RE512-RE514 RE524-RE526 RE530 RE532 RE536 RE537 RE539 RI13 RI14 RI27-RI30 RI47-RI50 RL1 RL2 RL4-RL6 RL9 RL11-RL20 RL29 RL30 RL70 RN37 RN100 RR3 RR4 RR19 RT1-RT8 RT10-RT39 RT41 RT42 RT50-RT53 RT64-RT69 RT71 RT74-RT76 RT81 RT82 RT84-RT86 RT89 RT90 RT95-RT98 RT100 RT101 RT103 RT106 RT107 RT110 RT111 RT124-RT129 RT336-RT339 RT371 RT372 RT377 RT391 RT393 RV1-RV8 RV10-RV23 RV26 RV29 RV32 RV35 RV70 RV71 RV73 RV74 RV76 RV77 RV79-RV85 RV87-RV91 RV93-RV95 RV97 RZ8-RZ10 RZ18-RZ23 RZ25 RZ28 RZ32 RZ38 RZ40 RZ43 RZ58-RZ60 RZ62 RZ63 RZ65 RZ69 RZ71 RZ76-RZ81 RZ111-RZ114 RZ116 RZ117 RZ119 RZ131 RZ132 RZ320 RZ326 RZ334 RZ335 RZ361 RZ362 = R_0402
PJP1 PJP2 PJP4 PJP6 PJP7 PJP13 PJP15 PJP16 PJP18-PJP22 PJP35 PJP37 PJP38 PJP42 PJP201 PJP391 PJP403 PJP404 PJP501 PJP502 PJP505 PJP506 PJP603 = JUMP_43X39
PJP3 PJP8 PJP31 PJP39 PJP41 PJP102 PJP103 PJP200 PJP302 PJP601 PJP1202 = JUMP_43X118
PJP5 PJP14 PJP17 PJP36 PJP40 PJP100 PJP101 PJP202 PJP301 PJP401 PJP402 PJP602 = JUMP_43X79
PJP901 = JUMP_43X118-NPM
PJPDC1 = CVILU_CI0805M1HRC-NH_5P-T
PL1 PL2 PL4 = TAIYO_FBMJ4516HS720NT_2P
PL3 = MURAT_BLM15AG102SN1D_2P
PL100 PL101 = CYNTE_PCMC063T-1R5MN_2P
PL201 = CYNTE_PCMB063T-1R0MS_2P
PL301 = MAG_MMD-05CZ-R68M-X2L_2P
PL402 PL404 PL501 = MAG_MLV-FY12N1R0M-O1L_2P
PL602 = 9A_Z80_1812_2P-NPM
PL610 PL612 = MAG_MMD06CZER15MG_4P
PL614 = MAG_MMD05CZR47M_4P
PL901 = MAGLA_MMD-05CZ-1R0M-M7L_2P
PL902 = CYNTE_PCMB103T-2R2MS_2P
PL1201 PL1202 = 5A_Z120_0805_2P
PQ1 PQ1201 PQ1204 PQ1209 PQ1214 QC2 QE2 QE13 QL1 QL2 QV3 QZ2 QZ7 = DMN65D8LDW-7_SOT363-6
PQ2 = FDV301N-G_SOT23-3
PQ3 = MMST3904-7-F_SOT323-3
PQ4 PQ9 PQ1202 PQ1206 PQ1213 = FDMC6679AZ_MLP8-5
PQ5 PQ1203 PQ1215 = NTR4502PT1G_SOT23-3
PQ6-PQ8 PQ909 PQ1205 PQ1212 PQ1216 = DMN65D8LW-7_SOT323-3
PQ501 = AON7934_DFN3X3A8-10
PQ904 = AON6970_DFN5X6D-8-7
PQ905 = AON6992_DFN5X6D-8-7
PQ906 = AON7409_DFN8-5
PQ1207 PQ1208 PQ1210 PQ1211 QT1 = DMN66D0LDW-7_SOT363-6
PR13 PR916 = R_0805
PR19-PR23 PR25 PR26 PR29 PR104 PR105 PR114 PR119 PR120 PR208 PR210 PR312 PR402 PR406 PR423 PR425 PR426 PR504 PR513 PR602 PR603 PR606 PR614 PR616 PR620 PR625 PR659 PR671 PR679 PR920 PR922 PR926 PR928 PR929 PR935 PR936 PR939 PR941 PR942 PR946 PR947 PR949 PR951 PR960 PR1211 PR1215 PR1216 PR1218 PR1220 PR1221 PR1223 PR1225 PR1238 PR1241-PR1245 PR1250 PR1257 RA35-RA39 RA48 RA54-RA56 RC33-RC38 RC40 RC41 RC62 RC170 RC171 RC173 RC212 RC214 RC221 RC228-RC231 RC235 RC244 RC290 RC295 RC296 RC300-RC308 RC325 RC328 RC337 RC373-RC378 RD5 RD7 RD9 RD12 RE30 RE32 RE34 RE59 RE90 RE275 RE290 RE318 RE360 RE364 RE506 RE515 RL3 RL7 RL34 RN99 RR5-RR10 RT9 RT40 RT54-RT60 RT63 RT70 RT72 RT73 RT83 RT87 RT88 RT92 RT93 RT99 RT104 RT105 RT108 RT109 RT120-RT123 RT341 RT342 RT392 RZ26 RZ29 RZ56 RZ61 RZ64 RZ70 RZ85 RZ87 RZ89 RZ120 RZ345-RZ347 RZ363 = R0402_0OHM
PR100 PR111 PR203 PR304 PR914 PR943 R274 RA3 RC143 RC169 RC216 RC299 RC309 RC310 RD10 RL8 = R0603_0OHM
PR106 PR112 PR202 PR303 PR627 PR663 PR676 PR923 PR924 = R_1206
PR405 PR409 PR502 PR619 PR624 PR660 PR661 PR672 PR674 PR921 RL71-RL78 RT48 RT49 RZ151 = R_0603
PR901 PR917 = R_1206_4P-D
PRP1 RPC1 RPC3 RPC4 RPE7 RPE9-RPE12 = RP_0804_8P4R
PT1 T1-T4 T9-T17 T50 T51 T88 T89 T113-T115 T120 T122 T123 T126 T127 T130 T132 T219 T220 T225 T226 T258 T262 T264 T267-T269 T283 = TPC12
PU1 PU903 PU1200 UC7 UE3 UE5 UL2 UZ6 UZ10 UZ34 UZ35 = TC7SH08FU_SSOP5
PU2 = AP2204RA-3P3TRG1_SOT89-3
PU100 = SY8288BRAC_QFN20_3X3
PU102 = SY8288CRAC_QFN20_3X3
PU200 = SY8210AQVC_QFN19_4X3
PU301 = SYX196DQNC_QFN10_3X3
PU401 PU402 = SY8057QDC_QFN16_3X3
PU501 = RT8097ALGE_SOT23-6
PU503 = AP7361C-FGE-7_U-DFN3030-8_3X3
PU602 = ISL62883CHRTZ-T_TQFN40_5X5-S
PU610 PU612 = CSD97374CQ4M_SON8_3P5X4P5
PU614 = ISL95808HRZ-TS2378_DFN8_2X2-S
PU901 = ISL88738HRTZ-T_TQFN32_4X4
PU1201 = LM393DGKR_VSSOP8
QE3-QE7 = MMBT3904WT1G_SC70-3
QE11 QE12 QR1 QV2 QV4 QV5 QV7 = L2N7002WT1G_SC-70-3
QV1 = AO6405_TSOP6
QV8 QZ1 QZ9 = LP2301ALT1G_SOT23-3
QZ3 = DDTA114EUA-7-F_SOT323-3
RE93 RZ128-RZ130 = R_0201
SW1 = SW_SS3-CMFTQR9_3P
SW3 = SW_SKRBAAE010_4P
TL1 = MHPC_NS692417_24P
UA1 = ALC3246-CG_MQFN48_6X6
UC1 = SKL-U_BGA_1356P-T
UC5 UC6 = W25Q128FVSIQ_SO8
UC8 = 74CBTLV3126BQ_DHVQFN14_2P5X3-S
UC12 = 74AHC1G09GW_TSSOP5
UD1 UE4 UE6 = 74AUP1G07GW_TSSOP5
UE1 = MEC5105_WFBGA_169P
UE2 = IT8010FN-BX-R_QFN20_4X4
UE7 UT7 = AP2112K-3P3TRG1_SOT23-5
UE9 UT2 UT6 = W25Q80DVSSIG_SO8
UI1 = SY6288D20AAC_SOT23-5
UI3 = SLGC55544CVTR_TQFN16_3X3
UL1 = WGI217LM-QPN9-A2_QFN48_6X6-S
UR1 = RTS5242-GR_QFN32_4X4-S
UT1 = ALPINE-RIDGE_BGA_337P
UT5 = TPS65982_BGA_96P
UT8 = AP2204R-5P0TRG1_SOT89-3
UV2 = AP2330W-7_SC59-3
UV7 = PS8338BQFN60GTR-A0_QFN60_5X9-S
UV24 = G524B1T11U_SOT23-5
UZ2-UZ5 = TPS22966DPUR_SON14_2X3
UZ8 = AOZ1336_DFN8_2X2
UZ12 = NPCT650JB2YX_QFN32_5X5
UZ19 UZ21 UZ26 = TPS22961DNYR_WSON8
YC1 = Y_X3G024000DC1H_4P
YC2 = Y_9H03200042_2P
YE1 = Y_X1A000141000200_2P
YL1 YT1 = Y_7V25000034_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WS-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
5A_Z120_0805_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
9A_Z80_1812_2P-NPM
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74CBTLV3126BQ_DHVQFN14_2P5X3-S
  oval 1.041x0.254 smd: 1(0,0) 7(2.95,0) 8(2.95,0.5) 14(0,0.5)
  oval 0.254x1.041 smd: 2(0.475,-0.975) 3(0.975,-0.975) 4(1.475,-0.975) 5(1.975,-0.975) 6(2.475,-0.975) 9(2.475,1.475) 10(1.975,1.475) 11(1.475,1.475) 12(0.975,1.475) 13(0.475,1.475)
  rect 1.499x0.991 smd: 15(1.475,0.25)
ACES_50209-0060N-P01_6P
  oval 0.508x1.651 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,-2.275) 8(5.3,-2.275)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50278-0040N-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50506-00641-P01_6P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.991x2.007 smd: 7(-2.1,-3.05) 8(4.6,-3.05)
ACES_50506-01041-P01_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(-2.1,-3.05) 12(6.6,-3.05)
ACON_HMRBL-A41L0F_19P-T
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.397x2.21 hole 0.787x1.6: 20(11.75,0.2) 22(-2.75,0.2)
  oval 1.702x2.997 hole 1.092x2.388: 21(13.25,-8.15) 23(-4.25,-8.15)
ACON_TCRA2-9U1U93_9P-T
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x2.311 hole 0.711x1.702: 10(2.9,0.3) 12(-9.9,0.3)
  oval 1.295x2.007 hole 0.711x1.397: 11(4.2,-8.95) 13(-11.2,-8.95)
ALC3246-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AO6405_TSOP6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
AON6970_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AOZ1336_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2112K-3P3TRG1_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.375) 5(0,2.375)
AP2204R-5P0TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2204RA-3P3TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AP7361C-FGE-7_U-DFN3030-8_3X3
  oval 0.457x0.94 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3.05) 6(1.3,3.05) 7(0.65,3.05) 8(0,3.05)
  rect 2.261x1.499 smd: 9(0.975,1.525)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BELLW_80149-3221_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CSD97374CQ4M_SON8_3P5X4P5
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 6(0.8,3.5) 7(0.4,3.5) 8(0,3.5)
  custom 0.225x0.225 smd: 4(2.2,0.262) 5(2.2,3.238)
  rect 4.039x2.21 smd: 9(1.6,1.75)
CVILU_CF4218FH0R0-05-NH_18P-T
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.406x0.787 smd: 19(-1,-2.5) 20(9.5,-2.5)
CVILU_CF5020FD0RK-05-NH_20P-T
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.651x1.397 smd: 21(-2.325,-3.375) 22(11.825,-3.375)
CVILU_CF5026FD0RK-05-NH_26P-T
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 1.651x1.397 smd: 27(14.825,-3.375) 28(-2.325,-3.375)
CVILU_CI0805M1HRC-NH_5P-T
  round 1.803 hole 1.803 unplated: (-0.2,5.2) (8.2,5.2)
  oval 0.889x2.388 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0)
  rect 1.6x2.489 smd: 6(11.15,9.05) 7(-3.15,9.05)
CVILU_CI1804M1VRA-NH_4P
  oval 0.508x0.991 smd: 1(0,-0.05) 2(-0.8,-0.05) 3(-1.6,-0.05) 4(-2.4,-0.05)
  rect 1.194x1.702 smd: 5(-3.7,1.4) 6(1.3,1.4)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMB103T-2R2MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYNTE_PCMC063T-1R5MN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
DB3J315E0L_SMINI3-F2-B3
  oval 0.889x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DDTA114EUA-7-F_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
DEREN_40-42251-01001RHF_10P-T
  oval 0.838x2.21 smd: 1(0,0.1) 2(1.5,0.1) 3(3,0.1) 4(4.5,0.1) 5(6,0.1) 6(7.5,0.1) 7(9,0.1) 8(10.5,0.1) 9(12,0.1) 10(13.5,0.1)
  custom 0.75x0.75 smd: 11(-3.4,-3.15) 12(16.9,-3.15)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_4251K-F06N-40L_6P
  oval 0.406x0.991 smd: 1(0,0) 2(0.6,0) 3(1.2,0) 4(1.8,0) 5(2.4,0) 6(3,0)
  rect 0.711x1.041 smd: 7(3.95,-1.575) 8(-0.95,-1.575)
E-T_6601K-Y61N-04L_61P
  oval 0.305x1.245 smd: 1(0,0) 3(0.6,0) 5(1.2,0) 7(1.8,0) 9(2.4,0) 11(3,0) 13(3.6,0) 15(4.2,0) 17(4.8,0) 19(5.4,0) 21(6,0) 23(6.6,0) 25(7.2,0) 27(7.8,0) 29(8.4,0) 31(9,0) 33(9.6,0) 35(10.2,0) 37(10.8,0) 39(11.4,0) 41(12,0) 43(12.6,0) 45(13.2,0) 47(13.8,0) 49(14.4,0) 51(15,0) 53(15.6,0) 55(16.2,0) 57(16.8,0) 59(17.4,0) 61(18,0)
  oval 0.305x0.94 smd: 2(0.3,3.25) 4(0.9,3.25) 6(1.5,3.25) 8(2.1,3.25) 10(2.7,3.25) 12(3.3,3.25) 14(3.9,3.25) 16(4.5,3.25) 18(5.1,3.25) 20(5.7,3.25) 22(6.3,3.25) 24(6.9,3.25) 26(7.5,3.25) 28(8.1,3.25) 30(8.7,3.25) 32(9.3,3.25) 34(9.9,3.25) 36(10.5,3.25) 38(11.1,3.25) 40(11.7,3.25) 42(12.3,3.25) 44(12.9,3.25) 46(13.5,3.25) 48(14.1,3.25) 50(14.7,3.25) 52(15.3,3.25) 54(15.9,3.25) 56(16.5,3.25) 58(17.1,3.25) 60(17.7,3.25)
  rect 0.305x1.143 smd: 62(-0.65,0.6) 63(18.65,0.6)
E-T_6705K-Y20N-00L_20P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 0.991x2.007 smd: 21(2.1,-3.15) 22(-11.6,-3.15)
ESD8011MUT5G_X3DFN2-2-S
  rect 0.33x0.356 smd: 1(0,0) 2(0.43,0)
FDMC6679AZ_MLP8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.537x0.537 smd: 5(0.975,2.075)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G524B1T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H_1P0N
  round 0.991 hole 0.991 unplated: (0,0)
H_2P3N
  round 2.311 hole 2.311 unplated: (0,0)
H_2P3X2P7N
  oval 2.311x2.692 hole 2.311x2.692 unplated: (0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_3P1-G
  round 3.607 hole 3.099: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P4
  round 3.912 hole 3.404: 1(0,0)
H_3P5-G
  round 4.013 hole 3.505: 1(0,0)
H_3P8-G
  round 4.318 hole 3.81: 1(0,0)
HB_A531015-SCHR21_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(6.6,-3.05) 12(-2.1,-3.05)
INPAQ_HCM2012GA900AE_4P
  rect 0.762x0.508 smd: 1(0,0) 2(1.85,0) 3(1.85,-0.9) 4(0,-0.9)
ISL62883CHRTZ-T_TQFN40_5X5-S
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
ISL88738HRTZ-T_TQFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
ISL95808HRZ-TS2378_DFN8_2X2-S
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.889 smd: 9(0.75,1.1)
IT8010FN-BX-R_QFN20_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 11(4.1,-2) 12(4.1,-1.5) 13(4.1,-1) 14(4.1,-0.5) 15(4.1,0)
  oval 0.254x0.889 smd: 6(1.05,-3.05) 7(1.55,-3.05) 8(2.05,-3.05) 9(2.55,-3.05) 10(3.05,-3.05) 16(3.05,1.05) 17(2.55,1.05) 18(2.05,1.05) 19(1.55,1.05) 20(1.05,1.05)
  rect 2.565x2.565 smd: 21(2.05,-1)
JAE_DX07B024XJ1R1300_24P
  round 0.711 hole 0.711 unplated: (-0.85,-0.66)
  oval 0.94x0.711 hole 0.94x0.711 unplated: (6.35,-0.66)
  oval 1.092x1.956 hole 0.61x1.448: 1(-2.05,-1.535) 2(7.55,-1.535)
  oval 1.092x2.388 hole 0.61x1.6: 3(-3.05,-5.76) 4(8.55,-5.76)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.21) B2(5.15,-2.01) B3(4.35,-2.01) B4(4.1,-1.21) B5(3.55,-2.01) B6(3.15,-1.21) B7(2.35,-1.21) B8(1.95,-2.01) B9(1.4,-1.21) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.21)
JAE_SF51S006V4DR1000Q_8P
  round 0.762 hole 0.762 unplated: (-2.19,-10.215)
  round 0.889 hole 0.889 unplated: (7.01,2.835)
  rect 0.991x0.838 smd: 1(10.765,-9.44)
  rect 0.889x0.61 smd: 2(-2.94,3.715)
  rect 1.245x1.803 smd: 3(-3.39,-13.165)
  rect 1.245x1.397 smd: 4(-3.39,-5.165)
  rect 1.295x1.016 smd: 5(-0.715,3.725) 6(9.535,3.725)
  rect 1.041x1.397 smd: 7(12.1,1.025)
  rect 0.94x1.397 smd: 8(12.55,-6.465)
  rect 1.219x1.143 smd: 9(10.795,-13.49)
  rect 0.889x0.762 smd: C1(0,0) C2(2.54,0) C3(5.08,0) C4(7.62,0) C5(0,-13.15) C6(2.54,-13.15) C7(5.08,-13.15) C8(7.62,-13.15)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LCN_DAN05-67306-0100_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LCN_DAN05-Q0406-0103_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,7.9) 262(-67.175,7.9)
